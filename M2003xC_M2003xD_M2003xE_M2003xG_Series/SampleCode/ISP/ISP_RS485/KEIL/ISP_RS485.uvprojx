# Keil uVision project ISP_RS485.uvprojx, settings and files
target ISP_RS485 (6120000::V6.12::.\ARMCLANG)
  device: M2003XC1AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: ISP_RS485
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M2003\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Core\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M2003_isp.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003/Source/: system_M2003.c
    ../: startup_M2003_isp.s
  group User
    ../: fmc_user.c isp_user.c targetdev.c main.c uart_transfer.c
  group ChipDef
    ../../../../Library/Device/Nuvoton/M2003/Include/: chip_type.h
