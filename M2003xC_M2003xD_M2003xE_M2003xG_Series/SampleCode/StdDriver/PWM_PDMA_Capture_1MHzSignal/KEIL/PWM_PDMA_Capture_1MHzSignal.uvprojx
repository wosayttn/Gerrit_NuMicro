# Keil uVision project PWM_PDMA_Capture_1MHzSignal.uvprojx, settings and files
target PWM_PDMA_Capture_1MHzSignal (6190000::V6.19::ARMCLANG)
  device: M2003SG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.6
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) IROM2(0x00100000,0x1000) IROM3(0x00200000,0x400) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: PWM_PDMA_Capture_1MHzSignal
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M2003\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M2003.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003/Source/ARM/: startup_M2003.s
    ../../../../Library/Device/Nuvoton/M2003/Source/: system_M2003.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c pwm.c pdma.c
  group User
    ../: main.c
  group ChipDef
    ../../../../Library/Device/Nuvoton/M2003/Include/: chip_type.h
software components: CMSIS:CORE 6.1.0
