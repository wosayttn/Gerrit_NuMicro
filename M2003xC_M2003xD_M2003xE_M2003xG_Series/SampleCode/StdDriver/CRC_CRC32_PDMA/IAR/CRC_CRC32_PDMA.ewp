# IAR project CRC_CRC32_PDMA.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2003xG6AE series Nuvoton M2003xG6AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M2003\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CRC_CRC32_PDMA.bin
  ILINK.IlinkOutputFile: CRC_CRC32_PDMA.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group ChipDef
    ../../../../Library/Device/Nuvoton/M2003/Include/: chip_type.h
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003/Source/IAR/: startup_M2003.s
    ../../../../Library/Device/Nuvoton/M2003/Source/: system_M2003.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c crc.c fmc.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c
