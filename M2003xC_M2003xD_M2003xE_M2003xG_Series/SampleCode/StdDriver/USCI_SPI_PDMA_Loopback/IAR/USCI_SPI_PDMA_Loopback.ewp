# IAR project USCI_SPI_PDMA_Loopback.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2003 series Nuvoton M2003 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M2003\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USCI_SPI_PDMA_Loopback.bin
  ILINK.IlinkOutputFile: USCI_SPI_PDMA_Loopback.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group ChipDef
    ../../../../Library/Device/Nuvoton/M2003/Include/: chip_type.h
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003/Source/IAR/: startup_M2003.s
    ../../../../Library/Device/Nuvoton/M2003/Source/: system_M2003.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pdma.c retarget.c sys.c uart.c usci_spi.c
  group User
    ../: main.c
