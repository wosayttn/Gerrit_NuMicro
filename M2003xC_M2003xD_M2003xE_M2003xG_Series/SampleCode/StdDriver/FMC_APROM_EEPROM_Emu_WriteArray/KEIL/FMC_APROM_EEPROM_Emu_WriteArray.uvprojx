# Keil uVision project FMC_APROM_EEPROM_Emu_WriteArray.uvprojx, settings and files
target FMC_APROM_EEPROM_Emu_WriteArray (6190000::V6.19::ARMCLANG)
  device: M2003XC1AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.6
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) IROM2(0x00100000,0x1000) IROM3(0x00200000,0x400) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: FMC_APROM_EEPROM_Emu_WriteArray
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M2003\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M2003.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003/Source/: system_M2003.c
    ../../../../Library/Device/Nuvoton/M2003/Source/ARM/: startup_M2003.s
  group User
    ../: main.c eeprom_emu.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c fmc.c
  group ChipDef
    ../../../../Library/Device/Nuvoton/M2003/Include/: chip_type.h
