# IAR project FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: SYSTEM_CORE_CLOCK=180000000
  ICCARM.IExtraOptions: --diag_suppress Pe550 --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\Source\include; ..; ..\..\Source\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\Source\include
  ILINK.IlinkOutputFile: tflu.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCOptLevel: 3
  group Source
    ../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_3.c
    ../../Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
