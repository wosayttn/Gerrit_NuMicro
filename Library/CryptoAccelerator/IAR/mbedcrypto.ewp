# IAR project mbedcrypto.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M5531x2LJAE series Nuvoton M5531x2LJAE series
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: MBEDTLS_CONFIG_FILE=mbedtls_config.h; MBEDTLS_MD_CAN_SHA256; MBEDTLS_MD_CAN_SHA1; MANUAL_ALIGNMENT
  ICCARM.CCDiagSuppress: Pe513, Pe144,Pe247, Pe546, Pe111
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Core\Include\; ..\..\Device\Nuvoton\M5531\Include\; ..\..\..\ThirdParty\mbedtls\library\; ..\..\..\ThirdParty\mbedtls\include\; ..\..\..\ThirdParty\mbedtls\; ..\..\CryptoAccelerator\; ..\..\..\Library\StdDriver\inc\; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mbedcrypto.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group crypto_accelerator
    ../: aes_alt.c ccm_alt.c ecdh_alt.c ecdsa_alt.c ecp_internal_alt.c gcm_alt.c platform_alt.c mbedtls_config.h rsa_alt.c sha256_alt.c hkdf_alt.c trng_api.c
  group mbedcrypto
    ../../../ThirdParty/mbedtls/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c threading.c timing.c version.c
