# Keil uVision project mbedcrypto.uvprojx, settings and files
target mbedcrypto (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: mbedcrypto (library)
  AfterMake: xcopy /Y .\Objects\mbedcrypto.lib ..\lib\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: MBEDTLS_CONFIG_FILE, MANUAL_ALIGNMENT
  c misc: -Wno-shift-count-overflow -Wno-absolute-value -Wno-shift-negative-value
  c include: ..\..\Device\Nuvoton\M3351\Include;..\..\..\ThirdParty\mbedtls-3.1.0\include;..\..\..\ThirdParty\mbedtls-3.1.0\library;..\..\..\ThirdParty\mbedtls-3.1.0;..\..\CryptoAccellerator;..\..\CMSIS\Core\Include;..\..\StdDriver\inc;..\
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\..\..\Library\Device\Nuvoton\M3351\Source\ARM\M3351.scf
  group crypto_accelerator
    ../: aes_alt.c ccm_alt.c gcm_alt.c platform_alt.c trng_api.c sha256_alt.c mbedtls_config.h
  group mbedcrypto
    ../../../ThirdParty/mbedtls-3.1.0/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c threading.c timing.c version.c
