# Keil uVision project CMSIS_DSP.uvprojx, settings and files
target Release (6240000::V6.24::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: cmsis_dsp (library)
  AfterMake: xcopy /Y .\Objects\cmsis_dsp.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: ARM_MATH_DSP, ARM_MATH_LOOPUNROLL, ARM_MATH_HELIUM, ARM_MATH_HELIUM_EXPERIMENTAL
  c include: ..\..\..\DSP\Include;..\..\..\DSP\PrivateInclude;..\..\..\Core\Include
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group BasicMathFunctions
    ../../../DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group BayesFunctions
    ../../../DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CommonTables
    ../../../DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group ComplexMathFunctions
    ../../../DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group ControllerFunctions
    ../../../DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group DistanceFunctions
    ../../../DSP/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
  group FastMathFunctions
    ../../../DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group FilteringFunctions
    ../../../DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group InterpolationFunctions
    ../../../DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group MatrixFunctions
    ../../../DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group QuaternionMathFunctions
    ../../../DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group StatisticsFunctions
    ../../../DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group SupportFunctions
    ../../../DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group SVMFunctions
    ../../../DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group TransformFunctions
    ../../../DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group WindowFunctions
    ../../../DSP/Source/WindowFunctions/: WindowFunctions.c
