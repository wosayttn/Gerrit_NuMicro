# Keil uVision project FMC_MultiBoot.uvprojx, settings and files
target FMC_MultiBoot (6220000::V6.22::ARMCLANG)
  device: M2003VJ7AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.6
  cpu: IRAM(0x20000000,0xC000) IROM(0x00000000,0x100000) IROM2(0x0F100000,0x1000) IROM3(0x0F200000,0x400) IROM4(0x0F400000,0x2000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: FMC_MultiBoot
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __BASE__
  c include: ..\..\..\..\Library\Device\Nuvoton\M2003J\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0xf100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --map --first='startup_M2003J_user.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003J/Source/: system_M2003J.c
    ./: startup_M2003J_user.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c sys.c uart.c
target FMC_Boot0 (6220000::V6.22::ARMCLANG)
  device: M2003VJ7AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.6
  cpu: IRAM(0x20000000,0xC000) IROM(0x00000000,0x100000) IROM2(0x00100000,0x1000) IROM3(0x00200000,0x400) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: FMC_Boot0
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT0__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: as above
target FMC_Boot1 (6220000::V6.22::ARMCLANG)
  device: M2003VJ7AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.6
  cpu: as above
  output: FMC_Boot1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT1__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: as above
target FMC_Boot2 (6220000::V6.22::ARMCLANG)
  device: M2003VJ7AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.6
  cpu: as above
  output: FMC_Boot2
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT2__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: as above
target FMC_BootLD (6220000::V6.22::ARMCLANG)
  device: M2003VJ7AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.6
  cpu: as above
  output: FMC_BootLD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: as above
