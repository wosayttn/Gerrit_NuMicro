# Keil uVision project CRC_CRC32_PDMA.uvprojx, settings and files
target CRC_CRC32_PDMA (6220000::V6.22::ARMCLANG)
  device: M2003VJ7AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.6
  cpu: IRAM(0x20000000,0xC000) IROM(0x00000000,0x100000) IROM2(0x0F100000,0x1000) IROM3(0x0F200000,0x400) IROM4(0x0F400000,0x2000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: CRC_CRC32_PDMA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M2003J\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0xf100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M2003J\Source\ARM\APROM.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003J/Source/ARM/: startup_M2003J.s
    ../../../../Library/Device/Nuvoton/M2003J/Source/: system_M2003J.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c crc.c pdma.c fmc.c
  group User
    ../: main.c
