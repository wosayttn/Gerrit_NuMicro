# IAR project FMC_CRC32.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2003xJ7AE series Nuvoton M2003xJ7AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M2003J\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: FMC_CRC32.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nuvoton\M2003xJ7AE.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003J/Source/IAR/: startup_M2003J.s
    ../../../../Library/Device/Nuvoton/M2003J/Source/: system_M2003J.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: main.c
