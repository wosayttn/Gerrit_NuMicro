# IAR project MP3_Player.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __WINS__; OPT_SPEED
  ICCARM.CCDiagSuppress: Pa082,Pe188,Pe549
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Core\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\m3331\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\ThirdParty\FATFS\source; $PROJ_DIR$..\..\..\..\..\ThirdParty\libmad\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: MP3_Player.bin
  ILINK.IlinkOutputFile: MP3_Player.out
  ILINK.IlinkIcfFile: MP3_Player.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/IAR/: startup_m3331.s
    ../../../../Library/Device/Nuvoton/m3331/Source/: system_m3331.c
  group FATFS
    ../../../../ThirdParty/FatFs/source/: ff.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c i2s.c pdma.c retarget.c sdh.c sys.c uart.c
  group MP3
    ../../../../ThirdParty/LibMAD/src/: bit.c decoder.c fixed.c frame.c huffman.c layer12.c layer3.c MP3Func.c stream.c synth.c timer.c version.c
  group Source
    ../: audio_codec.c diskio.c isr.c main.c mp3.c mp3headerparser.c sdglue.c
