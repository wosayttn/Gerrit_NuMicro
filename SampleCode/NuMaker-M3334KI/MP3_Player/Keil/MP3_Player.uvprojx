# Keil uVision project MP3_Player.uvprojx, settings and files
target MP3_Player (6220000::V6.22::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: MP3_Player
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __WINS__ OPT_SPEED
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\m3331\Include;..\..\..\..\ThirdParty\libmad\inc;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\INCLUDE;..\..\..\..\Library\UsbHostLib\INCLUDE\inc_mass;..\..\..\..\ThirdParty\FATFS\source;..\..\I2S_WavMP3Player_New
  asm define: Stack_Size=0x2000 Heap_Size=0x2000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_m3331.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/: system_m3331.c
    ../../../../Library/Device/Nuvoton/m3331/Source/ARM/: startup_m3331.s
  group Source
    ../: main.c diskio.c sdglue.c mp3.c mp3headerparser.c isr.c audio_codec.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c i2s.c i2c.c clk.c uart.c retarget.c pdma.c sdh.c gpio.c
  group FATFS
    ../../../../ThirdParty/FATFS/source/: ff.c
  group MP3Lib
    ../../../../ThirdParty/libmad/src/: version.c bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c MP3Func.c stream.c synth.c timer.c
