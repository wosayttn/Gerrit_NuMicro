<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\mbedTLS_PSA_AEAD.ewp</path>
  </project>
  <batchBuild/>
</workspace>

