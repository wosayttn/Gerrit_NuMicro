# IAR project mbedTLS_PSA_Cipher_AES.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; MBEDTLS_CONFIG_FILE="nvt_mbedtls_config.h"; TF_PSA_CRYPTO_CONFIG_FILE="nvt_crypto_config.h"; MBEDTLS_PSA_NVT_TEST_HOOKS; MBEDTLS_ARCH_IS_ARM32; MBEDTLS_ALLOW_PRIVATE_ACCESS=
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CryptoAccelerator\src; ..\..\..\..\Library\CryptoAccelerator\configs\target; ..\..\..\..\Library\CryptoAccelerator\configs\target; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\Device\Nuvoton\M2354\Include; ..\..\..\..\Library\CryptoAccelerator\integration\firmware-overlay\tf-psa-crypto\include; ..\..\..\..\Library\CryptoAccelerator\integration\firmware-overlay\tf-psa-crypto\core; ..\..\..\..\ThirdParty\mbedtls\include; ..\..\..\..\ThirdParty\mbedtls\tf-psa-crypto\core; ..\..\..\..\ThirdParty\mbedtls\tf-psa-crypto\dispatch; ..\..\..\..\ThirdParty\mbedtls\tf-psa-crypto\include; ..\..\..\..\ThirdParty\mbedtls\tf-psa-crypto\extras; ..\..\..\..\ThirdParty\mbedtls\tf-psa-crypto\utilities; ..\..\..\..\ThirdParty\mbedtls\tf-psa-crypto\platform; ..\..\..\..\ThirdParty\mbedtls\tf-psa-crypto\drivers\builtin\include; ..\..\..\..\ThirdParty\mbedtls\tf-psa-crypto\drivers\builtin\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AES.bin
  ILINK.IlinkOutputFile: AES.out
  ILINK.IlinkIcfFile: m2354.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../../../Library/Device/Nuvoton/M2354/Source/IAR/: startup_M2354.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c crypto.c gpio.c
  group symmetric_cipher_test
    ../: symmetric_ciphers_test_main.c
  group psa_core
    ../../../../ThirdParty/mbedtls/tf-psa-crypto/core/: psa_crypto.c psa_crypto_client.c psa_crypto_random.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c psa_util.c tf_psa_crypto_config.c tf_psa_crypto_version.c
    ../../../../Library/CryptoAccelerator/integration/firmware-overlay/tf-psa-crypto/core/: psa_crypto_driver_wrappers_no_static.c
  group psa_platform
    ../../../../ThirdParty/mbedtls/tf-psa-crypto/platform/: memory_buffer_alloc.c platform.c platform_util.c threading.c
  group psa_utilites
    ../../../../ThirdParty/mbedtls/tf-psa-crypto/utilities/: asn1parse.c asn1write.c base64.c constant_time.c oid.c pem.c pkcs5.c
  group psa_extras
    ../../../../ThirdParty/mbedtls/tf-psa-crypto/extras/: lmots.c lms.c md.c nist_kw.c pk.c pk_ecc.c pk_rsa.c pk_wrap.c pkparse.c pkwrite.c
  group psa_drivers_builtin
    ../../../../ThirdParty/mbedtls/tf-psa-crypto/drivers/builtin/src/: aes.c aesce.c aesni.c aria.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c camellia.c ccm.c chacha20.c chacha20_neon.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hmac_drbg.c md5.c poly1305.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_xof.c psa_util_internal.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha3.c sha256.c sha512.c
  group psa_drivers_nvt
    ../../../../Library/CryptoAccelerator/src/: psa_get_started_example.c nvt_cipher_driver_entrypoints.c nvt_hash_driver_entrypoints.c nvt_ecc_driver_entrypoints.c nvt_rsa_driver_entrypoints.c nvt_psa_ecc.c nvt_psa_rsa.c nvt_crpt.c nvt_aead_driver_entrypoints.c
  group nvt_psa_crypto_drivers
    ../../../../Library/CryptoAccelerator/src/: nvt_psa_sha.c nvt_psa_aes.c nvt_psa_gcm.c nvt_psa_ccm.c
