# Keil uVision project mbedTLS_HKDF.uvprojx, settings and files
target mbedTLS_HKDF (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: mbedTLS_HKDF
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: MBEDTLS_CONFIG_FILE, MBEDTLS_MD_CAN_SHA256,MBEDTLS_MD_CAN_SHA1
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CryptoAccelerator;..\..\..\..\ThirdParty\mbedtls\include;..\..\..\..\ThirdParty\mbedtls\library;..\..\..\..\ThirdParty\mbedtls\tests\include;..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M5531.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c retarget.c uart.c crypto.c kdf.c
  group User
    ../: test_suite_hkdf.c
  group mbedtls
    ../../../../ThirdParty/mbedtls/tests/src/: psa_crypto_helpers.c helpers.c random.c
    ../../../../Library/CryptoAccelerator/lib/: mbedcrypto.lib
