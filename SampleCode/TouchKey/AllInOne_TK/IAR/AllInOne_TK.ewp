# IAR project AllInOne_TK.ewp, settings and files
configuration TK_Calibration (ARM)
  General.OGChipSelectEditMenu: M2L31 series Nuvoton M2L31 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: DEMO_LED; DEMO_CALIBRATION; DEBUG_PORT=UART3; _DEBUG_ENABLE_SEMIHOST; LIB_CALIBRATION
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M2L31\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\TKLib\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AllInOne_TK.bin
  ILINK.IlinkOutputFile: AllInOne_TK.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration TK_FreeRun (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEMO_FREERUN; DEMO_USE_LED; DEBUG_PORT=UART3
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/IAR/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c rmc.c sys.c timer.c uart.c
  group Library
    ../: TK_UartCmd.c
    ../../../../Library/TKLib/: TKLib_Calibration.a TKLib_FreeRun.a
  group User
    ../: TK_DebugUART.c TK_Main.c TK_MassProduction.c TK_MultPinFunctions.c TK_Powerdown.c TK_SysTick.c TK_TC8260_AllInOne_Led.c
