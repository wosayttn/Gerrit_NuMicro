# Keil uVision project AllInOne_TK.uvprojx, settings and files
target TK_FreeRun_PY (6230000::V6.23::ARMCLANG)
  device: M258KG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: TouchKey_FreeRun_PY
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: DEMO_FREERUN,DEMO_USE_LED, DEBUG_PORT=UART3
  c include: ..\TouchKey;..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\TKLib\Include;..\..\..\..\Library\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
    ../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.s
  group Source
    ../: TK_DebugUART.c TK_Led.c TK_Main.c TK_MultPinFunctions.c TK_SysTick.c TK_MassProduction.c TK_Powerdown.c TK_TC8260_AllInOne_Led.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c uart.c timer.c sys.c retarget.c gpio.c rmc.c
  group Library
    ../../../../Library/TKLib/: TKLib_Calibration.lib TKLib_FreeRun.lib TKLib_MassProduction.lib
    ../: TK_UartCmd.c
target TK_Calibration_PY (6230000::V6.23::ARMCLANG)
  device: M258KE3AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: TouchKey_Calibration_PY
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: DEMO_LED DEMO_CALIBRATION DEBUG_PORT=UART3 _DEBUG_ENABLE_SEMIHOST LIB_CALIBRATION
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
