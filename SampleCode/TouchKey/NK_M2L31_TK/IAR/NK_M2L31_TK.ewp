# IAR project NK_M2L31_TK.ewp, settings and files
configuration Numaker_M2L31_TK_Calibration (ARM, debug)
  General.OGChipSelectEditMenu: M2L31 series Nuvoton M2L31 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: DEMO_CALIBRATION; MASS_FINETUNE; DEBUG_PORT=UART3
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M2L31\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\TKLib\Include; ..\..\..\..\Library\LCDLib\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NK_M2L31_TK.srec
  ILINK.IlinkOutputFile: NuMaker_M2L31_TK_Calibration.out
  ILINK.IlinkIcfFile: m2l31.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Numaker_M2L31_TK_FreeRun (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEMO_FREERUN; DEBUG_PORT=UART3
  ILINK.IlinkOutputFile: Numaker_M2L31_TK_FreeRun.out
  ILINK.IlinkKeepSymbols: TK_Data
  ILINK.IlinkExtraOptions: --no_remove
  group Driver
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c rmc.c sys.c timer.c uart.c
  group Inc
    ../: TK_Data.c
  group Library
    ../../../../Library/TKLib/: TKLib_Calibration.a TKLib_FreeRun.a
  group Source
    ../: TK_DebugUART.c TK_Main.c TK_MassProduction.c TK_MultPinFunctions.c TK_SysTick.c TK_UartCmd.c
  group Startup
    ../../../../Library/Device/Nuvoton/M2L31/Source/IAR/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
