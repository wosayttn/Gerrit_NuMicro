# Keil uVision project NK_M2L31_TK.uvprojx, settings and files
target Numaker_M2L31TK_FreeRun (6230000::V6.23::ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x2a000) IROM(0x00000000,0x80000) IROM2(0x0F100000,0x2000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: Numaker_M2L31TK_FreeRun
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEMO_FREERUN DEBUG_PORT=UART3
  c include: ..\TouchKey;..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\TkLib\Include;..\..\..\..\Library\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0xf100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  scatter file: .\TK_FreeRun.sct
  group Startup
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
    ../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.c
  group Library
    ../../../../Library/TkLib/: TKLib_Calibration.lib TKLib_FreeRun.lib TKLib_MassProduction.lib
  group Source
    ../: TK_DebugUART.c TK_Main.c TK_MultPinFunctions.c TK_SysTick.c TK_UartCmd.c TK_MassProduction.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c timer.c clk.c sys.c retarget.c gpio.c tk.c rmc.c
  group Inc
    ../: TK_Data.c
target Numaker_M2L31TK_Calibration (6230000::V6.23::ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: as above
  output: Numaker_M2L31TK_Calibration
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: DEMO_CALIBRATION,DEBUG_PORT=UART3
  c include: ..\..\TouchKey;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\TkLib\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\LCDLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0xf100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  scatter file: .\TK_Calibration.sct
