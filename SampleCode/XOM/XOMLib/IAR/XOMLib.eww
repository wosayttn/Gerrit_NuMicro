<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\XOMLib_Code.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\XOMLib.ewp</path>
    </project>
    <batchBuild />
</workspace>
