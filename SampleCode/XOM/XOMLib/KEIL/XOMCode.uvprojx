# Keil uVision project XOMCode.uvprojx, settings and files
target XOMCode (ARM-ADS)
  device: M471KI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.9
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: XOMCode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: ..\XOMAddr .\lst\XOMCode.map .\xomlib.c
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M471\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: xom_scatter.scf
  link misc: --map --first='startup_M471.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471/Source/ARM/: startup_M471.s
    ../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
  group User
    ../: main.c xom.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c fmc.c sys.c
