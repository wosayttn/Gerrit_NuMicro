# IAR project XOMLibDemo.ewp, settings and files
configuration Bank0 (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: DL_BANK=0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\m3331\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\XOMLib\lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: XOMLibDemo_Bank0.bin
  ILINK.IlinkOutputFile: XOMLibDemo.out
  ILINK.IlinkIcfFile: XOMLibDemo.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Bank1 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DL_BANK=1
  OBJCOPY.OOCOutputFile: XOMLibDemo_Bank1.bin
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
    ../../XOMLib/lib/: xomlib.a
  group User
    ../: main.c
