# Keil uVision project App.uvprojx, settings and files
target App (6190000::V6.19::ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.3
  cpu: IRAM(0x20000000,0x2a000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: App +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  link misc: --map --first='startup_M2L31.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
    ../../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.s
  group User
    ../: main.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c rmc.c wdt.c
target NewApp (6190000::V6.19::ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.3
  cpu: as above
  output: NewApp +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NewApp
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  link misc: as above
