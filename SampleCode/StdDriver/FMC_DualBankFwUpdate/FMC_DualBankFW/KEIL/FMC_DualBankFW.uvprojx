# Keil uVision project FMC_DualBankFW.uvprojx, settings and files
target FMC_DualBankFW (ARM-ADS)
  device: M471KI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(120000000) CPUTYPE("Cortex-M4") FPU2
  output: FMC_DualBankFW
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\..\..\..\Library\Device\Nuvoton\M471\Include;..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\common\inc;..\..\Dual_Bank_FW
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M471.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
    ../../../../../Library/Device/Nuvoton/M471/Source/ARM/: startup_M471.s
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c uart.c fmc.c wdt.c gpio.c
  group User
    ../../common/src/: NuDB_common.c
    ../: main.c
