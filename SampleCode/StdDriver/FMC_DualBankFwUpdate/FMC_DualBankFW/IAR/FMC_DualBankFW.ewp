# IAR project FMC_DualBankFW.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M471 series Nuvoton M471 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\M471\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\common\inc; ..\..\FMC_DualBankFW
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_DualBankFW.bin
  ILINK.IlinkOutputFile: FMC_Dual_Bank.out
  ILINK.IlinkIcfFile: M471.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M471/Source/IAR/: startup_M471.s
    ../../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
    ../../common/src/: NuDB_common.c
  group User
    ../: main.c
