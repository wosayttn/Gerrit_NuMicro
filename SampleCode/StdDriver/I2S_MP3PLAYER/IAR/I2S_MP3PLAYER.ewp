# IAR project I2S_MP3PLAYER.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: __WINS__; OPT_SPEED
  ICCARM.CCDiagSuppress: Pa082,Pe188,Pe549,Pe128
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\m3331\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FatFs\source; ..\..\..\..\ThirdParty\LibMAD\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: I2S_MP3PLAYER.bin
  ILINK.IlinkOutputFile: I2S_MP3PLAYER.out
  ILINK.IlinkIcfFile: I2S_MP3PLAYER.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c i2s.c pdma.c retarget.c sdh.c sys.c uart.c
  group MP3
    ../../../../ThirdParty/LibMAD/src/: bit.c decoder.c fixed.c frame.c huffman.c layer12.c layer3.c MP3Func.c stream.c synth.c timer.c version.c
  group Source
    ../: audio_codec.c isr.c main.c mp3.c mp3headerparser.c pseudofile.c
