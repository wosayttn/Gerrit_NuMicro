# Keil uVision project I2S_MP3PLAYER.uvprojx, settings and files
target I2S_MP3PLAYER (6230000::V6.23::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M33") FPU2 IROM(0x00000000,0x80000) IROM2(0x10000000,0x80000) IROM3(0x0F100000,0x2000) IRAM(0x20000000,0x50000) IRAM2(0x30000000,0x50000)
  output: I2S_MP3PLAYER
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __WINS__ OPT_SPEED
  c misc: -mno-unaligned-access -Wconditional-uninitialized
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\;..\..\..\..\Library\Device\Nuvoton\m3331\Config;..\..\..\..\Library\Device\Nuvoton\m3331\Include;..\..\..\..\ThirdParty\libMAD\inc;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\INCLUDE;..\..\..\..\Library\UsbHostLib\INCLUDE\inc_mass;..\..\..\..\ThirdParty\FatFs\source;..\..\I2S_WavMP3Player_New
  asm define: Stack_Size=0x2000 Heap_Size=0x2000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\m3331\Config\m3331_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/: system_m3331.c startup_m3331.c
  group Source
    ../: main.c mp3.c mp3headerparser.c isr.c audio_codec.c pseudofile.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c i2s.c i2c.c clk.c uart.c retarget.c pdma.c sdh.c gpio.c
  group MP3Lib
    ../../../../ThirdParty/libMAD/src/: version.c bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c MP3Func.c stream.c synth.c timer.c
