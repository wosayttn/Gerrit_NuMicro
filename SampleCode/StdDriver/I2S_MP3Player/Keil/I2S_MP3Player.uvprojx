# Keil uVision project I2S_MP3Player.uvprojx, settings and files
target I2S_MP3Player (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: I2S_MP3Player
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: __WINS__ OPT_SPEED
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Storage;..\;..\;..\..\..\..\Library\UsbHostLib\inc;..\..\..\..\ThirdParty\FatFs\source;..\..\I2S_MP3Player;..\..\..\..\ThirdParty\libmad\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  link misc: --pd="-DSTACK_SIZE=0x1000" --pd="-DHEAP_SIZE=0x2000"
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c i2s.c i2c.c pdma.c sdh.c
  group FATFS
    ../../../../ThirdParty/FATFS/source/: ff.c
  group MP3Lib
    ../../../../ThirdParty/libmad/src/: version.c bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c MP3Func.c stream.c synth.c timer.c
  group User
    ../: main.c sdglue.c mp3.c mp3headerparser.c isr.c audio_codec.c
    ../../../../Library/Storage/: diskio_SDH.c
