<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ELLSI_PDMA_Marquee_Y_Cable.ewp</path>
  </project>
  <batchBuild/>
</workspace>


