# IAR project ELLSI_PDMA_Marquee_Y_Cable.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\m3331\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ELLSI_PDMA_Marquee_Y_Cable.bin
  ILINK.IlinkOutputFile: ELLSI_PDMA_Marquee_Y_Cable.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c ellsi.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c
