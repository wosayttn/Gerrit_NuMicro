# IAR project CIR_TPWM_TRX.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M471 series Nuvoton M471 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M471\Include; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CIR_TPWM_TRX.bin
  ILINK.IlinkOutputFile: CIR_TPWM_TRX.out
  ILINK.IlinkIcfFile: CIR_TPWM_TRX.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../LIBRARY/Device/Nuvoton/M471/Source/IAR/: startup_M471.s
    ../../../../LIBRARY/Device/Nuvoton/M471/Source/: system_M471.c
  group Library Files
    ../../../../LIBRARY/StdDriver/src/: cir.c clk.c retarget.c sys.c timer.c timer_pwm.c uart.c
  group Source Files
    ../: main.c
