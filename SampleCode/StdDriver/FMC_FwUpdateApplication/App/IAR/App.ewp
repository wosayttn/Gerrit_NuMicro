# IAR project App.ewp, settings and files
configuration App (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\m3331\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\common\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: App.bin
  ILINK.IlinkOutputFile: App.out
  ILINK.IlinkIcfFile: App.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration NewApp (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NewApp
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\m3331\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\common\inc; ..\..\..\..\..\Library\NuMaker\xmodem
  OBJCOPY.OOCOutputFile: NewApp.bin
  ILINK.IlinkOutputFile: NewApp.out
  group CMSIS
    ../../../../../Library/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c wdt.c
  group User
    ../: main.c
