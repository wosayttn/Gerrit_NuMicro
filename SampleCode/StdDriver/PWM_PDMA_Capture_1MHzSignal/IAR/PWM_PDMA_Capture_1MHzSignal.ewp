# IAR project PWM_PDMA_Capture_1MHzSignal.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2U54xG6AE series Nuvoton M2U54xG6AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M2U51\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWM_PDMA_Capture_1MHzSignal.bin
  ILINK.IlinkOutputFile: PWM_PDMA_Capture_1MHzSignal.out
  ILINK.IlinkIcfFile: m2u51.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2U51/Source/IAR/: startup_M2U51.s
    ../../../../Library/Device/Nuvoton/M2U51/Source/: system_M2U51.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pdma.c pwm.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
