# Keil uVision project PWM_PDMA_Capture_1MHzSignal.uvprojx, settings and files
target PWM_PDMA_Capture_1MHzSignal (6190000::V6.19::ARMCLANG)
  device: M2U54KG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: PWM_PDMA_Capture_1MHzSignal
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: __DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\Device\Nuvoton\M2U51\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M2U51\Source\ARM\APROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2U51/Source/ARM/: startup_M2U51.c
    ../../../../Library/Device/Nuvoton/M2U51/Source/: system_M2U51.c
  group User
    ../: main.c
    ../../../../Library/Device/Nuvoton/M2U51/Source/: semihost.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c pwm.c timer.c pdma.c
