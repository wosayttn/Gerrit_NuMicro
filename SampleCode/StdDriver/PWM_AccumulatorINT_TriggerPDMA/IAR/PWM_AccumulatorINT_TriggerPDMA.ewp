# IAR project PWM_AccumulatorINT_TriggerPDMA.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M3351xJCAE series Nuvoton M3351xJCAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\CMSIS\Compiler\include; ..\..\..\..\Library\Device\Nuvoton\M3351\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWM_AccumulatorINT_TriggerPDMA.bin
  ILINK.IlinkOutputFile: PWM_AccumulatorINT_TriggerPDMA.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M3351\Source\IAR\M3351.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c pwm.c pdma.c
  group User
    ../: main.c
