# IAR project CRYPTO_ED25519.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M5531x2LJAE series Nuvoton M5531x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ILINK.IlinkOutputFile: CRYPTO_ED25519.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\IAR\M5531.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M5531\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CRYPTO_ED25519.bin
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c crypto.c rng.c retarget.c sys.c uart.c
  group ED25519
    ../: eddsa_ed25519.c eddsa_ed25519_example.c
  group User
    ../: main.c
