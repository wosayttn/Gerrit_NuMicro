# IAR project HSUSBH_USBH_UVC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M5531x2LJAE series Nuvoton M5531x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; MAX_ALT_PER_IFACE=12; MAX_EP_PER_IFACE=24
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pa089
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M5531\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\inc; ..\..\..\..\Library\UsbHostLib\src_core; ..\..\..\..\Library\UsbHostLib\src_uvc; ..\..\..\..\ThirdParty\libjpeg; ..\Display; ..; ..\..\..\..\Library\CMSIS\DSP\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HSUSBH_USBH_UVC.bin
  ILINK.IlinkOutputFile: HSUSBH_USBH_UVC.out
  ILINK.IlinkIcfFile: HSUSBH_USBH_UVC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Display
    ../Display/: Display.c drv_pdma.c Font8_16.c
    ../Display/LCD/: LCD_LT7381.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c ebi.c gpio.c pdma.c retarget.c sys.c timer.c uart.c
  group jepg_lib
    ../../../../ThirdParty/libjpeg/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemansi.c jmemmgr.c jquant1.c jquant2.c jutils.c rdbmp.c rdcolmap.c rdgif.c rdppm.c rdrle.c rdswitch.c rdtarga.c transupp.c wrbmp.c wrgif.c wrppm.c wrrle.c wrtarga.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci_0.c ohci_1.c usb_core.c
  group UsbHostLib_UVC
    ../../../../Library/UsbHostLib/src_uvc/: uvc_core.c uvc_driver.c uvc_parser.c
  group User
    ../: main.c
