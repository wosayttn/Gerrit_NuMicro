# IAR project HSUSBH_USBH_HID_Mouse_Keyboard.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\m3331\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HSUSBH_USBH_HID_Mouse_Keyboard.bin
  ILINK.IlinkOutputFile: HSUSBH_USBH_HID_Mouse_Keyboard.out
  ILINK.IlinkIcfFile: HSUSBH_USBH_HID_Mouse_Keyboard.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci.c usb_core.c
  group UsbHostLib_HID
    ../../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c
  group User
    ../: keycode_xlate.c main.c
