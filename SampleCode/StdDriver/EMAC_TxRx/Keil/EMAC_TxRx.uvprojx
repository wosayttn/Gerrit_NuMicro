# Keil uVision project EMAC_TxRx.uvprojx, settings and files
target EMAC_TxRx (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: EMAC_TxRx
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: NVT_ICACHE_OFF, NVT_DCACHE_OFF
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\emac
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c
    ../../../../Library/StdDriver/src/emac/: synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group User
    ../: main.c emac.c mii.c net.c
