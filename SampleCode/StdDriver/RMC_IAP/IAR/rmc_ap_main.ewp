# IAR project rmc_ap_main.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2L31 series Nuvoton M2L31 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M2L31\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rmc_ap_main.bin
  ILINK.IlinkOutputFile: rmc_ap_main.out
  ILINK.IlinkIcfFile: rmc_ap_main.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\rmc_ld_iap.bin,loaderImage1Base,.bin_image,4; --image_input Release\Exe\rmc_ld_iap.bin,loaderImage1Limit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/IAR/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c rmc.c sys.c uart.c
  group User
    ../: aprom_main.c
