# Keil uVision project HSUSBH_USBH_RNDIS.uvprojx, settings and files
target HSUSBH_USBH_RNDIS (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: HSUSBH_USBH_RNDIS
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STDIN_ECHO=0
  c misc: -Wconditional-uninitialized -Wno-unused-parameter -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\inc;..\..\..\..\Library\UsbHostLib\src_core;..\..\..\..\Library\UsbHostLib\src_rndis;..\..\..\..\ThirdParty\lwIP\src\include;..\lwip_port;..\rndis_static_dashboard;..
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: system_M55M1.c startup_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c timer.c
  group User
    ../: main.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci_0.c ohci_1.c usb_core.c
  group UsbHostLib_RNDIS
    ../../../../Library/UsbHostLib/src_rndis/: rndis_driver.c rndis_parser.c rndis_ctrl.c rndis_bulk.c rndis_priv.h
    ../../../../Library/UsbHostLib/inc/: usbh_rndis.h
  group lwIP_NoSys_Core
    ../../../../ThirdParty/lwIP/src/core/: init.c def.c inet_chksum.c mem.c memp.c netif.c pbuf.c stats.c timeouts.c sys_lwip.c ip.c udp.c tcp.c tcp_in.c tcp_out.c
    ../../../../ThirdParty/lwIP/src/core/ipv4/: ip4.c ip4_addr.c etharp.c dhcp.c
    ../../../../ThirdParty/lwIP/src/netif/: ethernet.c
  group Application
    ../rndis_static_dashboard/: rndis_dashboard_http.c
  group Network
    ../: rndis_lwip_time.c
    ../rndis_static_dashboard/: rndis_dashboard_netif.c
  group lwIP_Config
    ../rndis_static_dashboard/: lwipopts.h
