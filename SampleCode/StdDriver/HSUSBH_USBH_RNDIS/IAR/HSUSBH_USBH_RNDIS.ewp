# IAR project HSUSBH_USBH_RNDIS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\inc; ..\..\..\..\Library\UsbHostLib\src_core; ..\..\..\..\Library\UsbHostLib\src_rndis; ..\..\..\..\ThirdParty\lwIP\src\include; ..\rndis_static_dashboard; ..\lwip_port; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HSUSBH_USBH_RNDIS.bin
  ILINK.IlinkOutputFile: HSUSBH_USBH_RNDIS.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\IAR\M55M1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../rndis_static_dashboard/: rndis_dashboard_http.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group lwIP_Config
    ../rndis_static_dashboard/: lwipopts.h
  group lwIP_NoSys_Core
    ../../../../ThirdParty/lwIP/src/core/: def.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwIP/src/core/ipv4/: dhcp.c etharp.c ip4.c ip4_addr.c
    ../../../../ThirdParty/lwIP/src/netif/: ethernet.c
  group Network
    ../rndis_static_dashboard/: rndis_dashboard_netif.c
    ../: rndis_lwip_time.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci_0.c ohci_1.c usb_core.c
  group UsbHostLib_RNDIS
    ../../../../Library/UsbHostLib/src_rndis/: rndis_bulk.c rndis_ctrl.c rndis_driver.c rndis_parser.c
  group User
    ../: main.c
