# Keil uVision project LCD_RTC_Alarm_Wakeup.uvprojx, settings and files
target LCD_RTC_Alarm_Wakeup (6190000::V6.19::ARMCLANG)
  device: M2U54KG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: LCD_RTC_Alarm_Wakeup
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: __DEBUG_ENABLE_SEMIHOST, OPT_NuMaker_TNLCDSub_M254K_4P8V_V1_1=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M2U51\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\LCDLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M2U51\Source\ARM\APROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2U51/Source/ARM/: startup_M2U51.c
    ../../../../Library/Device/Nuvoton/M2U51/Source/: system_M2U51.c
  group User
    ../: main.c
    ../../../../Library/Device/Nuvoton/M2U51/Source/: semihost.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c lcd.c rtc.c gpio.c
    ../../../../Library/LCDLib/Source/: lcdlib.c
