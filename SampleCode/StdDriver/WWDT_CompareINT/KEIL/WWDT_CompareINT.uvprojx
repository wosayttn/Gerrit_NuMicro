# Keil uVision project WWDT_CompareINT.uvprojx, settings and files
target WWDT_CompareINT (6240000::V6.24::ARMCLANG)
  device: M3351KJCAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x30000000,0x20000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) IROM3(0x0F100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: WWDT_CompareINT
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=5 v6LangP=3 wLevel=2
  c define: STDIN_ECHO=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\CMSIS\compiler\include;..\..\..\..\Library\Device\Nuvoton\m3351\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M3351\Source\ARM\M3351.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c wwdt.c gpio.c
  group User
    ../: main.c
