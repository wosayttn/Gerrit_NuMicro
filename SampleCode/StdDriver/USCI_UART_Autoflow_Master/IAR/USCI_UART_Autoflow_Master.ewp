# IAR project USCI_UART_Autoflow_Master.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M251AE series Nuvoton M251AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 56
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST=2
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M251\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USCI_UART_Autoflow_Master.srec
  ILINK.IlinkOutputFile: USCI_UART_Autoflow_Master.out
  ILINK.IlinkIcfFile: m251.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/IAR/: startup_M251.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c usci_uart.c
  group User
    ../: main.c
