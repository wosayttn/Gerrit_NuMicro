# IAR project FMC_MultiBoot.ewp, settings and files
configuration FMC_MultiBoot_0x0 (ARM)
  General.OGChipSelectEditMenu: M3351xJCAE series Nuvoton M3351xJCAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\CMSIS\Compiler\include; ..\..\..\..\Library\Device\Nuvoton\M3351\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_0x0.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_0x0.out
  ILINK.IlinkConfigDefines: VECMAP_BASE=0x0
  ILINK.IlinkIcfFile: FMC_MultiBoot_APROM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration FMC_MultiBoot_0x20000 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_0x20000.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_0x20000.out
  ILINK.IlinkConfigDefines: VECMAP_BASE=0x20000
configuration FMC_MultiBoot_0x40000 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_0x40000.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_0x40000.out
  ILINK.IlinkConfigDefines: VECMAP_BASE=0x40000
configuration FMC_MultiBoot_0x80000 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_0x80000.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_0x80000.out
  ILINK.IlinkConfigDefines: VECMAP_BASE=0x80000
configuration FMC_MultiBoot_LDROM (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_LDROM.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_LDROM.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M3351\Source\IAR\M3351xG_LDROM.icf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: main.c
