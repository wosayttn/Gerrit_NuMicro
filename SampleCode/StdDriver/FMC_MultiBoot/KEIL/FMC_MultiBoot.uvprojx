# Keil uVision project FMC_MultiBoot.uvprojx, settings and files
target FMC_MultiBoot (6190000::V6.19::ARMCLANG)
  device: M2U54KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.27
  cpu: IRAM(0x20000000,0x2a000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: FMC_MultiBoot
  AfterMake: fromelf --bin ".\obj\Base\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\Base\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __BASE__
  c include: ..\..\..\..\Library\Device\Nuvoton\M2U51\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  scatter file: .\FMC_MultiBoot.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2U51/Source/: system_M2U51.c
    ./: startup_M2U51.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c sys.c uart.c
target FMC_Boot0 (6190000::V6.19::ARMCLANG)
  device: M2U54KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.27
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: FMC_Boot0
  AfterMake: fromelf --bin ".\obj\Boot0\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\Boot0\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT0__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\FMC_Boot0.sct
  link misc: as above
target FMC_Boot1 (6190000::V6.19::ARMCLANG)
  device: M2U54KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.27
  cpu: as above
  output: FMC_Boot1
  AfterMake: fromelf --bin ".\obj\Boot1\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\Boot1\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT1__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\FMC_Boot1.sct
  link misc: as above
target FMC_Boot2 (6190000::V6.19::ARMCLANG)
  device: M2U54KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.27
  cpu: as above
  output: FMC_Boot2
  AfterMake: fromelf --bin ".\obj\Boot2\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\Boot2\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT2__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\FMC_Boot2.sct
  link misc: as above
target FMC_BootLD (6190000::V6.19::ARMCLANG)
  device: M2U54KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.27
  cpu: as above
  output: FMC_BootLD
  AfterMake: fromelf --bin ".\obj\BootLD\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\BootLD\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __LDROM__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\FMC_BootLD.sct
  link misc: as above
