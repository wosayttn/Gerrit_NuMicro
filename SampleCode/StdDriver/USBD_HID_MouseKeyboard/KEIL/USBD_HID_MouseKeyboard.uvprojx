# Keil uVision project USBD_HID_MouseKeyboard.uvprojx, settings and files
target USBD_HID_MouseKeyboard (6240000::V6.24::ARMCLANG)
  device: M3331KGGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: USBD_HID_MouseKeyboard
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M3351\Include;..\..\..\..\Library\StdDriver\inc;..\..\USBD_HID_MouseKeyboard
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M3351\Source\ARM\M3351.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c gpio.c retarget.c uart.c usbd.c
  group User
    ../: main.c descriptors.c hid_mousekeyboard.c
