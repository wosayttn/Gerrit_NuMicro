# IAR project I3C_SecondaryController.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\m3331\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I3C_SecondaryController.bin
  ILINK.IlinkOutputFile: I3C_SecondaryController.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../Library/StdDriver/src/: i3c.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/IAR/: startup_m3331.s
    ../../../../Library/Device/Nuvoton/m3331/Source/: system_m3331.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
