# IAR project RMC_XOM.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2L31 series Nuvoton M2L31 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pe177
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M2L31\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RMC_XOM.bin
  ILINK.IlinkOutputFile: RMC_XOM.out
  ILINK.IlinkIcfFile: RMC_XOM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/IAR/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c rmc.c sys.c uart.c
  group User
    ../: main.c xom_add.c
