# Keil uVision project USBH_HID_Keyboard.uvprojx, settings and files
target USBH_HID_Keyboard (6220000::V6.22::ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.5
  cpu: IRAM(0x20000000,0x2A000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: USBH_HID_Keyboard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\inc
  asm define: Stack_Size=0x800 Heap_Size=0x1000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  link misc: --map --first='startup_M2L31.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
    ../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.s
  group User
    ../: main.c usbh_hid_kbd.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: hub.c mem_alloc.c ohci.c usb_core.c
  group UsbHostLib_HID
    ../../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c hid_parser.c
