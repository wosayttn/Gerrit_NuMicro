# Keil uVision project FMC_APWPROT.uvprojx, settings and files
target FMC_APWPROT (6220000::V6.22::ARMCLANG)
  device: M2U54KG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.8
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) IROM2(0x0F100000,0x1000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: FMC_APWPROT
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -mno-unaligned-access -Wconditional-uninitialized
  c include: ..\;..\..\..\..\Library\Device\Nuvoton\M2U51\Config;..\..\..\..\Library\Device\Nuvoton\M2U51\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0xf100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M2U51\Source\ARM\APROM.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2U51/Source/: system_M2U51.c
    ../../../../Library/Device/Nuvoton/M2U51/Source/ARM/: startup_M2U51.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c fmc.c
