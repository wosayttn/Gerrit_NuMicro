<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\I3C_Controller.ewp</path>
  </project>
  <batchBuild/>
</workspace>


