# IAR project NonSecure.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: M3351xJCAE series Nuvoton M3351xJCAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: NVT_CMSE_NON_SECURE; DEBUG_PORT=UART1_NS; NVT_DBG_UART_OFF; SYSTEM_CORE_CLOCK=144000000
  ICCARM.IExtraOptions: --diag_suppress Pe550 --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\CMSIS\Compiler\include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\tz_demo; ..\..\..\..\..\Library\Device\Nuvoton\M3351\Include; ..\..; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM33\non_secure; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM33\secure
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: NonSecure.srec
  ILINK.IlinkOutputFile: NonSecure.out
  ILINK.IlinkIcfFile: M3351_ns.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSELib
    ../../CMSELib/: nsclib_iar.o
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group Demos
    ../../tz_demo/: tz_demo.c
  group Driver
    ../../../../../Library/StdDriver/src/: gpio.c retarget.c
  group FreeRTOS
    ../../../../../ThirdParty/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM33/non_secure/: port.c portasm.s
  group User
    ../: main_ns.c
