# Keil uVision project NonSecure.uvprojx, settings and files
target NonSecure (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: NonSecure
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\release\@L.bin"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: NVT_CMSE_NON_SECURE, NVT_VECTOR_ON_FLASH, DEBUG_PORT=UART1_NS, NVT_DBG_UART_OFF, SYSTEM_CORE_CLOCK=220000000
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\..\Library\StdDriver\inc;..\..;..\..\tz_demo;..\..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55\non_secure;..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55\secure;..\..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\NonSecure.scf
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c gpio.c
  group User
    ../: main_ns.c
  group CMSELib
    ../../CMSELib/: nsclib_keil.o
  group Demos
    ../../tz_demo/: tz_demo.c
  group FreeRTOS
    ../../../../../ThirdParty/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55/non_secure/: port.c portasm.c
