# IAR project Secure.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: M5531x2LJAE series Nuvoton M5531x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NVT_VECTOR_ON_FLASH
  ICCARM.IExtraOptions: --diag_suppress Pe550 --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55\secure; ..\..\tz_demo; ..\..\..\..\..\Library\Device\Nuvoton\M5531\Include; ..\..; ..\..\..\..\..\Library\StdDriver\inc\scu
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..
  OBJCOPY.OOCOutputFile: Secure.srec
  ILINK.IlinkOutputFile: Secure.out
  ILINK.IlinkIcfFile: M5531_s.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Driver
    ../../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c pmc.c retarget.c sys.c uart.c
    ../../../../../Library/StdDriver/src/scu/: mpc_sie_drv.c
  group NSCFunctions
    ../../tz_demo/: nsc_functions.c
  group SecureContext
    ../../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55/secure/: secure_context.c secure_context_port_asm.s
  group SecureHeap
    ../../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55/secure/: secure_heap.c
  group SecureInit
    ../../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55/secure/: secure_init.c
  group User
    ../: main_s.c
