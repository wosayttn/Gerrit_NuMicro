# Keil uVision project Blinky.uvprojx, settings and files
target Blinky (6240000::V6.24::ARMCLANG)
  device: M471KI8AE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.3
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(120000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M471\Include;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\Blinky
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M471.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group System
    ../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
    ../../../../Library/Device/Nuvoton/M471/Source/ARM/: startup_M471.s
  group Demo Files
    ../: main.c ParTest.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: QueueSet.c flash.c PollQ.c
  group FreeRTOS files
    ../../../../ThirdParty/FreeRTOS/Source/: tasks.c timers.c list.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c
