# Keil uVision project RTOSDemo.uvprojx, settings and files
target M2354 (6180000::V6.18::ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: RTOSDemo
  c flags: v6Lang=5
  c include: ..\;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM0;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M2354\Include;..\..\..\..\Library\StdDriver\inc
  asm define: Heap_Size=0x3800
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\secure.sct
  group System
    ../../../../Library/StdDriver/src/: sys.c retarget.c clk.c
    ../../../../Library/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.S
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../: partition_M2354.h
  group FreeRTOS source
    ../../../../ThirdParty/FreeRTOS/Source/: timers.c list.c queue.c tasks.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM0/: port.c
  group Demo App Source
    ../: main.c main-blinky.c main-full.c ParTest_M2354.c FreeRTOSConfig.h
    ./: RegTest_Keil.s
  group Common Demo Tasks
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c QueueSet.c QueueOverwrite.c
