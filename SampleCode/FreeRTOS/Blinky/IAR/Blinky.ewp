# IAR project Blinky.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: SYSTEM_CORE_CLOCK=220000000; NVT_VECTOR_ON_FLASH
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55_NTZ\non_secure; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: SYSTEM_CORE_CLOCK=25000000
  AARM.AUserIncludes: ..; ..\..\..\..\ThirdParty\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: Blinky.bin
  ILINK.IlinkOutputFile: Blinky.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group CommonDemo
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: blocktim.c countsem.c dynamic.c QueueOverwrite.c QueueSet.c recmutex.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure/: port.c portasm.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main-blinky.c main-full.c main.c ParTest.c Reg_Test.c
