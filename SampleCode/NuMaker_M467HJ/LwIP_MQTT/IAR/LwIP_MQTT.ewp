# IAR project LwIP_MQTT.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxJHAE series Nuvoton M46xxJHAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __TARGET_FPU_VFP; LWIP_ENABLE_CLIENT_CA=1; FREERTOS; MBEDTLS_ALLOW_PRIVATE_ACCESS; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  ICCARM.CCDiagSuppress: Pa082,Pe550,Pe177,Pe549,pa167,Pa181,Pe188
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\m460\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; ..\..\lwip\drv_emac; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\IAR\ARM_CM4F; ..\..\lwip\include; ..\..\..\..\ThirdParty\lwip\src\include\; ..\..\..\..\ThirdParty\mbedtls-3.1.0\include; ..; ..\..\..\..\ThirdParty\mbedtls-3.1.0\library; ..\..\..\..\ThirdParty\mbedtls-3.1.0\tests\include; ..\src\mbedtls_app; ..\src\mqtt_app; ..\src\config; ..\..\..\..\ThirdParty\paho.mqtt.embedded-c\MQTTPacket\src; ..\..\..\..\ThirdParty\lwIP\src\include\lwip
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __TARGET_FPU_VFP
  AARM.AUserIncludes: $PROJ_DIR$..\..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\..\Library\Device\Nuvoton\m460\Include; $PROJ_DIR$..\..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; $PROJ_DIR$..\..\; $PROJ_DIR$..\..\..\Common\include
  OBJCOPY.OOCOutputFile: LwIP_MQTT.bin
  ILINK.IlinkOutputFile: LwIP_MQTT.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_m460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group drv_emac
    ../../lwIP/drv_emac/: m460_emac.c m460_mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c QueueSet.c semtest.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c crypto.c fmc.c retarget.c sys.c uart.c
  group lwIP
    ../../../../ThirdParty/lwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwIP/src/netif/: ethernet.c
    ../../lwIP/netif/: ethernetif.c
    ../../lwIP/: sys_arch.c time_stamp.c
  group mbedtls
    ../../../../ThirdParty/mbedtls-3.1.0/library/: aes.c aesni.c aesni.h aria.c asn1parse.c asn1write.c base64.c bignum.c bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdh_misc.h ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h gcm.c hkdf.c hmac_drbg.c md.c md5.c md_wrap.h memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_wrap.c pk_wrap.h pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_misc.h ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_keys.h ssl_tls13_server.c threading.c timing.c version.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
    ../../../../ThirdParty/mbedtls-3.1.0/tests/src/: certs.c
  group MQTT
    ../../../../ThirdParty/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group MQTT_App
    ../src/app/: lan.c
    ../src/mbedtls_app/: lwip_tls.c platform_alt.c threading_alt.c
    ../src/mqtt_app/: mqtt-client.c mqtt-tcp.c
  group User
    ../: main.c
