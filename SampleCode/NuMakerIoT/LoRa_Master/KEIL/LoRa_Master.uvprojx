# Keil uVision project LoRa_Master.uvprojx, settings and files
target LoRa_Master (6120000::V6.12::.\ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: LoRa_Master
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SX1276MB1MAS USE_MODEM_LORA
  c include: ..\LoRaNode\mcu\M2354\Include;..\LoRaNode\board;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library;..\..\..\..\Library\Device\Nuvoton\M2354\Include;..\..\..\..\ThirdParty\SX1276\boards;..\..\..\..\ThirdParty\SX1276\system;..\..\..\..\ThirdParty\SX1276\radio;..\..\..\..\ThirdParty\SX1276\radio\sx1276;..\..\..\..\ThirdParty\SX1276\system
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.S
    ../LoRaNode/mcu/M2354/Device/Nuvoton/M2354/Source/: system_M2354.c
  group Library
    ../../../../Library/StdDriver/src/: uart.c clk.c retarget.c spi.c sys.c timer.c gpio.c rtc.c
  group User
    ../: main.c
  group LoRa_board
    ../../../../ThirdParty/SX1276/boards/mcu/: utilities.c
    ../LoRaNode/board/: spi-board.c gpio-board.c board.c lpm-board.c rtc-board.c uart-board.c
    ../../../../ThirdParty/SX1276/boards/: sx1276mb1mas-board.c
  group LoRa_radio
    ../../../../ThirdParty/SX1276/radio/sx1276/: sx1276.c
  group LoRa_system
    ../../../../ThirdParty/SX1276/system/: gpio.c timer.c delay.c uart.c systime.c fifo.c
