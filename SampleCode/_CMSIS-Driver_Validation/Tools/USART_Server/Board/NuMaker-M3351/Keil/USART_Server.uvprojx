# Keil uVision project USART_Server.uvprojx, settings and files
target USART_Server (6240000::V6.24::ARMCLANG)
  device: M3351KJCAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x30000000,0x20000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) IROM3(0x0F100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: USART_Server
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: RTE_CMSIS_DV_USART
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\..\..\Library\Device\Nuvoton\M3351\Include;..\..\..\..\..\..\..\Library\CMSIS\Driver\Include;..\..\..\..\..\..\..\Library\StdDriver\inc;..;..\..\..\Include;..\Config;..\..\..\..\..\..\..\Library\CMSIS\Driver\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: ..\..\..\..\..\..\..\Library\Device\Nuvoton\M3351\Source\ARM\M3351.scf
  link misc: --pd="-DSTACK_SIZE=0x800" --pd="-DHEAP_SIZE=0x4000"
  group Device
    ../../../../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group StdDriver
    ../../../../../../../Library/StdDriver/src/: clk.c pdma.c sys.c uart.c usci_uart.c retarget.c
  group CMSIS Driver
    ../../../../../../../Library/CMSIS/Driver/Source/RTE_Device/: RTE_Device.h RTE_Device_USART.h
    ../../../../../../../Library/CMSIS/Driver/Source/: misc.c drv_pdma.c
    ../../../../../../../Library/CMSIS/Driver/Source/Driver_USART/: Driver_USART_UART.c Driver_USART_UUART.c
  group USART_Server
    ../Config/: USART_Server_Config.h USART_Server_HW.c
    ../../../Source/: USART_Server.c
  group User
    ../../../../../Boards/Nuvoton/CMSIS_DV_USART/: USART_PinConfig.h
    ../: main.c vio_NuMaker-M3351.c
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS Driver:VIO:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0
