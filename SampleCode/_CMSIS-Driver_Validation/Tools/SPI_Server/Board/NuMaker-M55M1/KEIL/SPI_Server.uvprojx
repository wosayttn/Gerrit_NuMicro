# Keil uVision project SPI_Server.uvprojx, settings and files
target SPI_Server (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: SPI_Server
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NVT_DCACHE_ON = 0
  c include: ..\..\..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\..\..\..\Library\CMSIS\Driver\Include;..\..\..\..\..\..\..\Library\StdDriver\inc;..;..\..\..\Include;..\Config;..\..\..\..\..\..\..\Library\CMSIS\Driver\Source
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  link misc: --pd="-DSTACK_SIZE=0x4000" --pd="-DHEAP_SIZE=0x4000"
  group Device
    ../../../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group StdDriver
    ../../../../../../../Library/StdDriver/src/: clk.c pdma.c sys.c uart.c spi.c lpspi.c lppdma.c
  group CMSIS Driver
    ../../../../../../../Library/CMSIS/Driver/Source/RTE_Device/: RTE_Device.h
    ../../../../../../../Library/CMSIS/Driver/Source/: retarget.c drv_pdma.c misc.c drv_lppdma.c
    ../../../../../../../Library/CMSIS/Driver/Source/Driver_SPI/: Driver_SPI.c Driver_SPI_LPSPI.c
  group SPI_Server
    ../Config/: SPI_Server_Config.h
    ../../../Source/: SPI_Server.c
  group User
    ../: main.c vio_NuMaker-M55M1.c
software components: CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:VIO:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS:Keil RTX5 5.5.4, CMSIS:RTOS2:Keil RTX5 5.5.4
