# Keil uVision project CMSIS_DV_Storage.uvprojx, settings and files
target CMSIS_DV_Storage_RTX (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: CMSIS_DV_Storage
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: x_DEBUG
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  group Device
    ../../../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group BSP Driver
    ../../../../../../Library/StdDriver/src/: clk.c fmc.c sys.c uart.c retarget.c
  group CMSIS Driver
    ../../../../../../Library/CMSIS/Driver/Source/RTE_Device/: RTE_Device.h
    ../../../../../../Library/CMSIS/Driver/Source/: __Driver_Storage.c
  group User
    ../: main.c main_rtx.c
target CMSIS_DV_Storage (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: as above
  output: CMSIS_DV_Storage
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: _DEBUG
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: as above
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0
