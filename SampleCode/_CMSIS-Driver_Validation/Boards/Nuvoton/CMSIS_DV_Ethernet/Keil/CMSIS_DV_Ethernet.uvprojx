# Keil uVision project CMSIS_DV_Ethernet.uvprojx, settings and files
target CMSIS_DV_Ethernet (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.0
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: CMSIS_DV_Ethernet
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: OS_PRIVILEGE_MODE = 1
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\..\Library\CMSIS\Driver\Include;..\..\..\..\..\..\Library\StdDriver\inc\emac
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scf
  group Device
    ../../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group BSP Driver
    ../../../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c
    ../../../../../../Library/StdDriver/src/emac/: synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group CMSIS Driver
    ../../../../../../Library/CMSIS/Driver/Source/: Driver_ETH_MAC.c
  group User
    ../: main.c
software components: CMSIS Driver Validation:Ethernet 1.4.0, CMSIS Driver Validation:Framework 2.0.0, CMSIS Driver:Ethernet:Custom 1.0.0, CMSIS Driver:Flash:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0
