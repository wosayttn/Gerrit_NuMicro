# Keil uVision project CMSIS_DV_SAI_Codec.uvprojx, settings and files
target CMSIS_DV_SAI_Codec (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_DV_SAI_Codec
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: NVT_DCACHE_ON = 0,
  c include: ..\..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\..\Library\CMSIS\Driver\Include;..\..\..\..\..\..\Library\CMSIS\Driver\Source
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  group Device
    ../../../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group BSP Driver
    ../../../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c i2s.c gpio.c pdma.c i2c.c spi.c
  group CMSIS Driver
    ../../../../../../Library/CMSIS/Driver/Source/Driver_SAI/: Driver_SAI_I2S.c Driver_SAI_SPII2S.c
    ../../../../../../Library/CMSIS/Driver/Source/: drv_pdma.c
  group User
    ../: main.c
software components: CMSIS Driver Validation:Framework 2.0.0, CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:SAI:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0
