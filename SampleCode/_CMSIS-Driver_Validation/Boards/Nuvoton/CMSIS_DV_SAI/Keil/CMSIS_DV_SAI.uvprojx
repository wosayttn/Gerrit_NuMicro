# Keil uVision project CMSIS_DV_SAI.uvprojx, settings and files
target CMSIS_DV_SAI (6240000::V6.24::ARMCLANG)
  device: M3351KJCAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x30000000,0x20000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) IROM3(0x0F100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_DV_SAI
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: OS_PRIVILEGE_MODE = 1
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\..\Library\Device\Nuvoton\M3351\Include;..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\..\Library\CMSIS\Driver\Include;..\..\..\..\..\..\Library\CMSIS\Driver\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: ..\..\..\..\..\..\Library\Device\Nuvoton\M3351\Source\ARM\M3351.scf
  link misc: --pd="-DSTACK_SIZE=0x2000" --pd="-DHEAP_SIZE=0x2000"
  group Device
    ../../../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group BSP Driver
    ../../../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c gpio.c pdma.c spi.c
  group CMSIS Driver
    ../../../../../../Library/CMSIS/Driver/Source/: drv_pdma.c
    ../../../../../../Library/CMSIS/Driver/Source/Driver_SAI/: Driver_SAI_SPII2S.c
  group User
    ../: main.c
target CMSIS_DV_SAI_PLDM (6240000::V6.24::ARMCLANG)
  device: M3351KJCAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: as above
  output: CMSIS_DV_SAI
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: ..\..\..\..\..\..\Library\Device\Nuvoton\M3351\Source\ARM\M3351_RunInSRAM.scf
software components: CMSIS Driver Validation:Framework 2.0.0, CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:SAI:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0
