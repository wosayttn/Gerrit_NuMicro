# Keil uVision project CMSIS_DV_CAN.uvprojx, settings and files
target CMSIS_DV_CAN (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_DV_CAN
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: __PLDM_EMU__, OS_PRIVILEGE_MODE=1
  c include: ..\..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\..\Library\Device\Nuvoton\M3351\Include;..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\..\Library\CMSIS\Driver\Include;..\..\..\..\..\..\Library\CMSIS\Driver\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\..\..\..\..\..\Library\Device\Nuvoton\M3351\Source\ARM\M3351.scatter
  group Device
    ../../../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group BSP Driver
    ../../../../../../Library/StdDriver/src/: clk.c sys.c uart.c canfd.c retarget.c
  group CMSIS Driver
    ../../../../../../Library/CMSIS/Driver/Source/: Driver_CAN.c
    ../../../../../../Library/CMSIS/Driver/Source/RTE_Device/: RTE_Device.h
  group User
    ../: main.c
software components: CMSIS Driver Validation:CAN 1.4.0, CMSIS Driver Validation:Framework 2.0.0, CMSIS Driver:CAN:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0
