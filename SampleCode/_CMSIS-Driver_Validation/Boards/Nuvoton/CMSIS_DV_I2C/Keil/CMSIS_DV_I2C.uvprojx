# Keil uVision project CMSIS_DV_I2C.uvprojx, settings and files
target CMSIS_DV_I2C (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: CMSIS_DV_I2C
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\..\Library\CMSIS\Driver\Include;..\..\..\;..\..\..\..\..\..\Library\CMSIS\Driver\Source
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scf
  group CMSIS
    ../../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c i2c.c gpio.c lpi2c.c pdma.c lppdma.c usci_i2c.c
    ../../../../../../Library/StdDriver/inc/: lpgpio.h
  group User
    ../: main.c i2c_pair.c
  group CMSIS_DRIVER
    ../../../../../../Library/CMSIS/Driver/Source/Driver_I2C/: Driver_I2C.c Driver_I2C_LPI2C.c Driver_I2C_UI2C.c Driver_I2C_I3C.c
