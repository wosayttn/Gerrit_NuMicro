# Keil uVision project CMSIS_DV_SPI_SPIM.uvprojx, settings and files
target CMSIS_DV_SAI (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: CMSIS_DV_SAI
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: OS_PRIVILEGE_MODE = 1, NVT_DCACHE_ON = 0,
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\..\Library\CMSIS\Driver\Include;..\..\..\..\..\..\Library\CMSIS\Driver\Source;..\..\..\..\..\..\Library\CMSIS\Driver\Source\Driver_SPI
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  group Device
    ../../../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group BSP Driver
    ../../../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c gpio.c pdma.c spi.c spim.c qspi.c usci_spi.c
  group CMSIS Driver
    ../../../../../../Library/CMSIS/Driver/Source/: drv_pdma.c
    ../../../../../../Library/CMSIS/Driver/Source/Driver_SPI/: Driver_SPI.c Driver_SPI_LPSPI.c Driver_SPI_QSPI.c Driver_SPI_SPIM.c Driver_SPI_USPI.c
  group User
    ../: main.c
software components: CMSIS Driver Validation:Framework 2.0.0, CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:SAI:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0
