# Keil uVision project CMSIS_DV_USBD_Vcom_DualPort.uvprojx, settings and files
target CMSIS_DV_USBD_VCOM_DualPort (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: CMSIS_DV_USBD_VCOM_DualPort
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: OS_PRIVILEGE_MODE=1
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\..\..\Library\CMSIS\Driver\Include;..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\..\Library\CMSIS\Driver\Source
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scf
  link misc: --pd="-DSTACK_SIZE=0x1000" --pd="-DHEAP_SIZE=0x4000"
  group Device
    ../../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group StdDriver
    ../../../../../../Library/StdDriver/src/: clk.c pdma.c lppdma.c sys.c uart.c scuart.c lpuart.c usci_uart.c
  group CMSIS Driver
    ../../../../../../Library/CMSIS/Driver/Source/RTE_Device/: RTE_Device.h RTE_Device_USART.h
    ../../../../../../Library/StdDriver/src/: retarget.c
    ../../../../../../Library/CMSIS/Driver/Source/: misc.c drv_pdma.c drv_lppdma.c
    ../../../../../../Library/CMSIS/Driver/Source/Driver_USBD/: Driver_USBD.c Driver_USBD_HSUSBD.c
    ../../../../../../Library/CMSIS/Driver/Source/Driver_USART/: Driver_USART_UART.c Driver_USART_SC_UART.c Driver_USART_LPUART.c Driver_USART_UUART.c
  group User
    ../../CMSIS_DV_USART/: USART_PinConfig.h
    ../: main.c
  group USB_VCOM
    ../: VirtualCOM.c USBD_User_CDC_ACM_UART_0.c USBD_User_CDC_ACM_UART_1.c
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS Driver:USB Device:Custom 1.0.0, CMSIS Driver:VIO:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, USB:CORE 8.0.0, USB:Device:CDC 8.0.0, USB:Device 8.0.0
