# IAR project LwIP_MQTT.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: SYSTEM_CORE_CLOCK=220000000; __TARGET_FPU_VFP; LWIP_ENABLE_CLIENT_CA=1; FREERTOS; MBEDTLS_CONFIG_FILE
  ICCARM.CCDiagSuppress: Pa082,Pe550,Pe177,Pe549,pa167,Pa181,Pe188
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55_NTZ\non_secure; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\lwIP\include; ..\..\lwIP\drv_emac; ..\..\..\..\ThirdParty\lwIP\src\include; ..\; ..\..\..\..\Library\StdDriver\inc\emac; ..\src\mbedtls_app; ..\..\..\..\ThirdParty\mbedtls\include; ..\..\..\..\ThirdParty\mbedtls\library; ..\..\..\..\ThirdParty\mbedtls\tests\include; ..\src\mqtt_app; ..\src\config; ..\..\..\..\ThirdParty\paho.mqtt.embedded-c\MQTTPacket\src; ..\..\..\..\ThirdParty\lwIP\src\include\lwip
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\ThirdParty\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: LwIP_MQTT.bin
  ILINK.IlinkOutputFile: LwIP_MQTT.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\IAR\M55M1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group drv_emac
    ../../lwIP/drv_emac/: emac.c mii.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c QueueSet.c semtest.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure/: port.c portasm.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c fmc.c
    ../../../../Library/StdDriver/src/emac/: synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group lwIP
    ../../../../ThirdParty/lwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwIP/src/netif/: ethernet.c
    ../../lwIP/netif/: ethernetif.c
    ../../lwIP/: sys_arch.c time_stamp.c
  group mbedtls
    ../../../../ThirdParty/mbedtls/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
  group MQTT
    ../../../../ThirdParty/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group MQTT_App
    ../src/app/: lan.c
    ../src/mbedtls_app/: lwip_tls.c platform_alt.c threading_alt.c
    ../src/mqtt_app/: mqtt-client.c mqtt-tcp.c
  group User
    ../: main.c
