# IAR project BitBand.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxGCAE series Nuvoton M46xxGCAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\Device\Nuvoton\m3331\Include; ..\..\..\..\Library\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: BitBand.bin
  ILINK.IlinkOutputFile: BitBand.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/IAR/: startup_m3331.s
    ../../../../Library/Device/Nuvoton/m3331/Source/: system_m3331.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
