# IAR project ISP_MSC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M5531x2LJAE series Nuvoton M5531x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; NVT_ISP_FUNC
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M5531\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ISP_MSC.bin
  ILINK.IlinkOutputFile: ISP_MSC.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\IAR\M5531-LDROM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../common/: ISP_startup_M5531.c ISP_system_M5531.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c usbd.c
  group User
    ../: DataFlashProg.c descriptors.c main.c MassStorage.c
