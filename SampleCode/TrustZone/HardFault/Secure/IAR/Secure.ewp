# IAR project Secure.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M5531x2LJAE series Nuvoton M5531x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; DEBUG_PORT=UART0_NS
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\M5531\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HardFault_Secure.bin
  ILINK.IlinkOutputFile: HardFault_Secure.out
  ILINK.IlinkIcfFile: M5531_s.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c retarget.c sys.c uart.c
    ../../../../../Library/StdDriver/src/scu/: mpc_sie_drv.c
  group User
    ../: main.c
    ../../: partition_M5531.h
