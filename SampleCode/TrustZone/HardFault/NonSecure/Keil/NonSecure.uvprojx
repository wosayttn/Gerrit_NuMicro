# Keil uVision project NonSecure.uvprojx, settings and files
target Nonsecure (6230000::V6.23::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x50000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE IROM2(0x10000000,0x80000) IROM3(0x0F100000,0x2000) IRAM2(0x30000000,0x50000)
  output: Nonsecure +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c define: DEBUG_PORT=UART0_NS, __NONSECURE_CODE=1
  c misc: -mno-unaligned-access -Wconditional-uninitialized
  c include: ..\..\;..\..\..\..\..\Library\CMSIS\Core\Include;..\..\;..\..\..\..\..\Library\Device\Nuvoton\m3331\Config;..\..\..\..\..\Library\Device\Nuvoton\m3331\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\Nonsecure
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: nonsecure.sct
  group CMSIS
    ../../../../../Library/Device/Nuvoton/m3331/Source/: system_m3331.c startup_m3331.c
  group User
    ../: main_ns.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c gpio.c
    ../../Secure/lib/: nsclib_Secure.o
