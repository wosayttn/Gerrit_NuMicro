# IAR project Secure.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG; DEBUG_PORT=UART0
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\m3331\Include; ..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: --cmse
  OBJCOPY.OOCOutputFile: Secure.bin
  postbuild: cmd.exe /c copy "Release\Exe\nsclib_Secure_IAR.o" "..\lib"
  ILINK.IlinkOutputFile: Secure.out
  ILINK.IlinkIcfFile: M3331_s.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c
  group User
    ../: main.c
