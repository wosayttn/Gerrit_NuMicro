# Keil uVision project LwIP_MQTT.uvprojx, settings and files
target LwIP_MQTT (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: LwIP_MQTT
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SYSTEM_CORE_CLOCK=220000000, LWIP_ENABLE_CLIENT_CA=1 FREERTOS MBEDTLS_CONFIG_FILE
  c misc: -Wno-format -Wno-macro-redefined -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55_NTZ\non_secure;..\..\lwIP\include;..\..\lwIP\drv_emac;..\..\..\..\ThirdParty\lwIP\src\include;..\;..\..\..\..\Library\StdDriver\inc\emac;..\src\mbedtls_app;..\..\..\..\ThirdParty\mbedtls\include;..\..\..\..\ThirdParty\mbedtls\library;..\..\..\..\ThirdParty\mbedtls\tests\include;..\src\mqtt_app;..\src\config;..\..\..\..\ThirdParty\paho.mqtt.embedded-c\MQTTPacket\src;..\..\..\..\ThirdParty\lwIP\src\include\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group User
    ../: main.c
  group drv_emac
    ../../lwIP/drv_emac/: emac.c mii.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: list.c tasks.c timers.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c semtest.c QueueSet.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55_NTZ/non_secure/: port.c portasm.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c fmc.c
    ../../../../Library/StdDriver/src/emac/: synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group LwIP
    ../../lwip/: sys_arch.c time_stamp.c
    ../../lwip/netif/: ethernetif.c
    ../../../../ThirdParty/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwip/src/netif/: ethernet.c
  group MQTT_App
    ../src/app/: lan.c
    ../src/mbedtls_app/: lwip_tls.c platform_alt.c threading_alt.c
    ../src/mqtt_app/: mqtt-client.c mqtt-tcp.c
  group MQTT
    ../../../../ThirdParty/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mbedtls
    ../../../../ThirdParty/mbedtls/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
