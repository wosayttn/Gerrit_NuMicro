# Keil uVision project SPI_SDCard_FATFS.uvprojx, settings and files
target SPI_SDCard_FATFS (6240000::V6.24::ARMCLANG)
  device: M253LE3AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.9
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000) IROM2(0x00100000,0x1000)
  output: SPI_SDCard_FATFS
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M253\Include;..\..\..\..\_ThirdParty\FatFs\source;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M253\Source\ARM\APROM.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
    ../../../../Library/Device/Nuvoton/M253/Source/ARM/: startup_M253.c
  group User
    ../: main.c sdcard.c diskio.c
    ../../../../_ThirdParty/FatFs/source/: ff.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c retarget.c spi.c uart.c
