# Keil uVision project ConditionalUninitializedVariable.uvprojx, settings and files
target ConditionalUninitializedVariable (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x00150000) IRAM2(0x30100000,0x00150000) IROM(0x00100000,0x00200000) IROM2(0x10100000,0x00200000) XROM(0x0F100000,0x00002000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: ConditionalUninitializedVariable
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\CMSIS\compiler\include;..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\inc;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\Library\StdDriver\inc\emac;..\..\..\..\Library\StdDriver\inc\gdma;..\..\..\..\Library\StdDriver\inc\scu;..\..\..\..\Library\PowerDeliveryLib\Include\Inc;..\..\..\..\Library\PowerDeliveryLib\Include;..\..\..\..\Library\JpegAcceleratorLib\include;..\..\..\..\Library\SmartcardLib\include
  library: MicroLIB
  memory RVCT1: ROM 0xf100000 size 0x2000
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  group User
    ../: main.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Library/StdDriver
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c acmp.c bpwm.c canfd.c crc.c crypto.c dac.c eadc.c ebi.c ecap.c eqei.c fmc.c gpio.c i2c.c i3c.c pdma.c qspi.c rng.c rtc.c spi.c timer.c timer_pwm.c trng.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c awf.c ccap.c dmic.c epwm.c hsusbd.c i2s.c kdf.c kpi.c ks.c lpadc.c lpgpio.c lpi2c.c lppdma.c lpspi.c lptmr.c lptmr_pwm.c lpuart.c otfc.c pmc.c sc.c scuart.c sdh.c spim.c spim_hyper.c ttmr.c utcpd.c
    ../../../../Library/StdDriver/src/scu/: dpm.c fvc.c mpc_sie_drv.c
    ../../../../Library/StdDriver/src/gdma/: dma350_address_remap_template.c dma350_ch_drv.c dma350_drv.c dma350_lib.c
    ../../../../Library/StdDriver/src/emac/: synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group Library/Commu
    ../../../../Library/Commu/: xmodem.c
  group Library/Storage
    ../../../../Library/Storage/: diskio_USBHost.c
  group Library/UsbHostLib
    ../../../../Library/UsbHostLib/src_cdc/: cdc_core.c cdc_driver.c cdc_parser.c
    ../../../../Library/UsbHostLib/src_core/: hub.c mem_alloc.c usb_core.c ehci.c ehci_iso.c ohci_0.c ohci_1.c
    ../../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c
    ../../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
    ../../../../Library/UsbHostLib/src_uac/: uac_core.c uac_driver.c uac_parser.c
    ../../../../Library/UsbHostLib/src_uvc/: uvc_core.c uvc_driver.c uvc_parser.c
  group 3rdlib
    ../../../../ThirdParty/FatFs/source/: ff.c ffsystem.c ffunicode.c
  group Library/PowerDeliveryLib
    ../../../../Library/PowerDeliveryLib/: PD_DRP.lib PD_SRC.lib PD_SNK.lib
    ../../../PowerDelivery/UTCPD_DualRole/: usb_pd_policy.c usb_MultipleFunction.c usb_powerctrl.c
