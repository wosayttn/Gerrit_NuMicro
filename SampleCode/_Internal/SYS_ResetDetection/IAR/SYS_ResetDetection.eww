<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SYS_ResetDetection.ewp</path>
    </project>
    <batchBuild />
</workspace>
