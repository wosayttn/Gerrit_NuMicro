# Keil uVision project PSIO_MBI5153.uvprojx, settings and files
target PSIO_MBI5153 (6240000::V6.24::ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000) IROM2(0x00100000,0x1000)
  output: PSIO_MBI5153
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -fshort-enums -fshort-wchar -Wconditional-uninitialized
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\PSIO_MBI5153
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M251\Source\ARM\APROM.scf
  link misc: --pd="-DFLASH_SIZE=0x40000 -DSRAM_SIZE=0x8000 -DSTACK_SIZE=0x200 -DHEAP_SIZE=0x200"
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.c
  group Library
    ../: MBI5153_driver_LED.c MBI5153_LED_pattern.c
    ../../../../Library/StdDriver/src/: clk.c retarget.c timer.c pdma.c uart.c
  group User
    ../: main.c
