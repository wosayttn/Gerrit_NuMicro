# Keil uVision project SFUD.uvprojx, settings and files
target SFUD (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x00150000) IRAM2(0x30100000,0x00150000) IROM(0x00100000,0x00200000) IROM2(0x10100000,0x00200000) XROM(0x0F100000,0x00002000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: SFUD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=5 v6LangP=3 wLevel=2
  c define: NVT_DCACHE_ON = 0
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\_SFUD\inc;..\..\SFUD
  library: MicroLIB
  memory RVCT1: ROM 0xf100000 size 0x2000
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c spi.c qspi.c spim.c usci_spi.c lpspi.c
  group User
    ../: main.c nu_sfud_port.c
  group SFUD
    ../../../../ThirdParty/_SFUD/src/: sfud.c sfud_sfdp.c
