# Keil uVision project NuvotonAudioGUI_Firmware.uvprojx, settings and files
target NuvotonAudioGUI_Firmware (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) IROM3(0x0F100000,0x2000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: NuvotonAudioGUI_Firmware
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=5 v6LangP=3 wLevel=2
  c define: NVT_DCACHE_ON = 0
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\Library\StdDriver\inc;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: system_M5531.c startup_M5531.c
  group Library
    ../../../../Library/StdDriver/src/: fmc.c sys.c clk.c gpio.c retarget.c hsusbd.c i2s.c i2c.c pdma.c timer.c uart.c
  group User
    ../: main.c
    ../src/: adc_converter.c codec_config.c descriptors.c HIRC_autoTrim.c i2c_process.c sys_init.c usbd_audio.c user_config.c
