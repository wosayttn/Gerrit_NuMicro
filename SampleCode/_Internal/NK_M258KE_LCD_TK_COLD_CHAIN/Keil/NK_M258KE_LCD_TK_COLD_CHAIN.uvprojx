# Keil uVision project NK_M258KE_LCD_TK_COLD_CHAIN.uvprojx, settings and files
target NK_M258KE_LCD_TK_COLD_CHAIN_FreeRun (6240000::V6.24::ARMCLANG)
  device: M258KE3AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000) IROM2(0x00100000,0x1000)
  output: NK_M258KE_LCD_TK_COLD_CHAIN_FreeRun
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEMO_FREERUN
  c misc: -Wconditional-uninitialized
  c include: ..\..\TouchKey;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\TkLib\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\LCDLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\TK_FreeRun.scf
  group Startup
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    ../../../../Library/TkLib/: TKLib_Calibration.lib TKLib_FreeRun.lib TKLib_MassProduction.lib
  group Source
    ../: TK_Main.c TK_MultPinFunctions.c
    ../../../NuMaker-M258KE/NK_M258KE_LCD_TK/: TK_DebugUART.c TK_MassProduction.c TK_SysTick.c TK_UartCmd.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c timer.c clk.c sys.c retarget.c gpio.c tk.c fmc.c
  group Temperature
    ../../../../Library/StdDriver/src/: eadc.c
    ../../../NuMaker-M258KE/NK_M258KE_LCD_TK/: ADC_Vtemp.c
  group LCD
    ../../../../Library/StdDriver/src/: lcd.c
    ../../../../Library/LCDLib/Source/: lcdlib.c
    ../../../NuMaker-M258KE/NK_M258KE_LCD_TK/: LCD_NK.c
target NK_M258KE_LCD_TK_COLD_CHAIN_Calibration (6240000::V6.24::ARMCLANG)
  device: M258KE3AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.0
  cpu: as above
  output: NK_M258KE_LCD_TK_COLD_CHAIN_Calibration
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEMO_CALIBRATION,MASS_FINETUNE,DEBUG_PORT=UART1
  c misc: -Wconditional-uninitialized
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\TK_Calibration.scf
