# IAR project NK_M258KE_LCD_TK_COLD_CHAIN.ewp, settings and files
configuration NK_M258KE_LCD_TK_COLD_CHAIN_Calibration (ARM, debug)
  General.OGChipSelectEditMenu: M251AE series Nuvoton M251AE series (M251,M252,M254,M256,M258)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: DEMO_CALIBRATION; MASS_FINETUNE; DEBUG_PORT=UART1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M251\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\TKLib\Include; ..\..\..\..\Library\LCDLib\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NK_M258KE_LCD_TK_COLD_CHAIN.srec
  ILINK.IlinkOutputFile: NK_M258KE_LCD_TK_COLD_CHAIN_Calibration.out
  ILINK.IlinkIcfFile: m251.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration NK_M258KE_LCD_TK_COLD_CHAIN_FreeRun (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEMO_FREERUN; DEBUG_PORT=UART1
  ILINK.IlinkOutputFile: NK_M258KE_LCD_TK_COLD_CHAIN_FreeRun.out
  ILINK.IlinkExtraOptions: --no_remove
  group Driver
    ../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c retarget.c sys.c timer.c uart.c
  group LCD
    ../../../../Library/StdDriver/src/: lcd.c
    ../../../NuMaker-M258KE/NK_M258KE_LCD_TK/: LCD_NK.c
    ../../../../Library/LCDLib/Source/: lcdlib.c
  group Library
    ../../../../Library/TKLib/: TKLib_Calibration.a TKLib_FreeRun.a
  group Source
    ../../../NuMaker-M258KE/NK_M258KE_LCD_TK/: TK_DebugUART.c TK_MassProduction.c TK_SysTick.c TK_UartCmd.c
    ../: TK_Main.c TK_MultPinFunctions.c
  group Startup
    ../../../../Library/Device/Nuvoton/M251/Source/IAR/: startup_M251.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Temperature
    ../../../NuMaker-M258KE/NK_M258KE_LCD_TK/: ADC_Vtemp.c
    ../../../../Library/StdDriver/src/: eadc.c
