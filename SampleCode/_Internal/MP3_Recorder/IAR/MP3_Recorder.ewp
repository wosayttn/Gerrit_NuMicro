# IAR project MP3_Recorder.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M5531x2LJAE series Nuvoton M5531x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; __WINS__; OPT_SPEED
  ICCARM.CCDiagSuppress: Pe550,Pa082,Pe188,Pe068,Pe177,Pa093
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M5531\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\inc; ..\..\..\..\Library\UsbHostLib\src_core; ..\..\..\..\Library\UsbHostLib\src_msc; ..\..\..\..\Library\Storage\; ..\..\..\..\ThirdParty\FatFs\source; ..\..\..\..\ThirdParty\libmad\inc; ..\..\..\..\ThirdParty\shine\src\lib; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MP3_Recorder.bin
  ILINK.IlinkOutputFile: MP3_Recorder.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\IAR\M5531.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c i2s.c pdma.c retarget.c sdh.c spim_hyper.c sys.c uart.c
  group MP3Lib
    ../../../../ThirdParty/libmad/src/: bit.c decoder.c fixed.c frame.c huffman.c layer12.c layer3.c MP3Func.c stream.c synth.c timer.c version.c
  group SHINE
    ../../../../ThirdParty/shine/src/lib/: bitstream.c huffm.c l3.c l3bitstream.c l3loop.c l3mdct.c l3subband.c reservoir.c tables.c
  group Source
    ../: audio_codec.c hyperram_code.c isr.c main.c mp3.c mp3headerparser.c mp3recorder.c sdglue.c mp3_storage.c
    ../../../../Library/Storage/: diskio_SDH.c
