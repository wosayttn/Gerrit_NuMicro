# IAR project I2C_PDMA.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M253AE series Nuvoton M253AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 56
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Core\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\M253\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_PDMA.bin
  ILINK.IlinkOutputFile: I2C_PDMA.out
  ILINK.IlinkIcfFile: M253.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M253\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/IAR/: startup_M253.s
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c
