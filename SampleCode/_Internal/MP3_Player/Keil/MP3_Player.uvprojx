# Keil uVision project MP3_Player.uvprojx, settings and files
target MP3_Player (6240000::V6.24::ARMCLANG)
  device: M3351KJCAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x30000000,0x20000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) IROM3(0x0F100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: MP3_Player
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STDIN_ECHO=0, __WINS__ OPT_SPEED
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\CMSIS\compiler\include;..\..\..\..\Library\Device\Nuvoton\M3351\Include;..\..\..\..\Library\StdDriver\inc;..\;..\..\..\..\Library\UsbHostLib\inc;..\..\..\..\Library\UsbHostLib\src_core;..\..\..\..\Library\UsbHostLib\src_msc;..\..\..\..\Library\Storage;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\ThirdParty\_libmad\inc;..\..\MP3_Player
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M3351\Source\ARM\M3351.scf
  link misc: --pd="-DSTACK_SIZE=0x1000" --pd="-DHEAP_SIZE=0x1000"
  group CMSIS
    ../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c i2c.c pdma.c spi.c
  group FATFS
    ../../../../ThirdParty/FATFS/source/: ff.c
  group MP3Lib
    ../../../../ThirdParty/_libmad/src/: version.c bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c MP3Func.c stream.c synth.c timer.c
  group User
    ../: main.c mp3.c mp3headerparser.c isr.c audio_codec.c mp3_storage.c
    ../../../../Library/Storage/: diskio_USBHost.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: hub.c mem_alloc.c usb_core.c ohci.c
  group UsbHostLib_MSC
    ../../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
