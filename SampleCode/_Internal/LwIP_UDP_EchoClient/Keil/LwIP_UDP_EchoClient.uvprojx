# Keil uVision project LwIP_UDP_EchoClient.uvprojx, settings and files
target LwIP_UDP_EchoClient (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: LwIP_UDP_EchoClient
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: SYSTEM_CORE_CLOCK=220000000
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55_NTZ\non_secure;..\..\lwIP\include;..\..\lwIP\drv_emac;..\..\..\..\ThirdParty\lwIP\src\include;..\;..\..\..\..\Library\StdDriver\inc\emac
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group User
    ../: main.c udp_echoclient-netconn.c
  group drv_emac
    ../../lwIP/drv_emac/: emac.c mii.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: list.c tasks.c timers.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c semtest.c QueueSet.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55_NTZ/non_secure/: port.c portasm.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c
    ../../../../Library/StdDriver/src/emac/: synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group LwIP
    ../../lwip/: sys_arch.c time_stamp.c
    ../../lwip/netif/: ethernetif.c
    ../../../../ThirdParty/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwip/src/netif/: ethernet.c
