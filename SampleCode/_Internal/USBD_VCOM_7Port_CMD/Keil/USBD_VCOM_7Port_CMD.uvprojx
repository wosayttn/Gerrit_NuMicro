# Keil uVision project USBD_VCOM_7Port_CMD.uvprojx, settings and files
target USBD_VCOM_7Port_CMD (6240000::V6.24::ARMCLANG)
  device: M253LE3AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000) IROM2(0x00100000,0x1000)
  output: USBD_VCOM_7Port_CMD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized
  c include: .\;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M253\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M253\Source\ARM\APROM.scf
  link misc: --pd="-DSRAM_SIZE=0x3000 -DSTACK_SIZE=0x400 -DHEAP_SIZE=0x400"
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
    ../../../../Library/Device/Nuvoton/M253/Source/ARM/: startup_M253.c
  group User
    ../: descriptors.c main.c vcom_7port.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c clk.c sys.c uart.c usci_uart.c
