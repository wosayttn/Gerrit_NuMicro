# Keil uVision project Codec_ControlBoard.uvprojx, settings and files
target Codec_ControlBoard (6220000::V6.22::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.3
  cpu: IRAM(0x20000000,0x50000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU2 CLOCK(12000000) IROM2(0x10000000,0x80000) IROM3(0x0F100000,0x2000) IRAM2(0x30000000,0x50000)
  output: Codec_ControlBoard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -mno-unaligned-access -Wconditional-uninitialized
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\;..\..\..\..\Library\Device\Nuvoton\m3331\Config;..\..\..\..\Library\Device\Nuvoton\m3331\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\m3331\Config\m3331_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
  group User
    ../: main.c
    ../src/: adc_converter.c codec_config.c descriptors.c HIRC_autoTrim.c i2c_process.c sys_init.c usbd_audio.c user_config.c
  group Library
    ../../../../Library/StdDriver/src/: fmc.c sys.c clk.c gpio.c retarget.c hsusbd.c i2s.c i2c.c pdma.c timer.c uart.c
