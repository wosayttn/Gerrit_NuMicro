# Keil uVision project LVGL_WidgetsDemo.uvprojx, settings and files
target LVGL_WidgetsDemo (6220000::V6.22::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.3
  cpu: IRAM(0x20000000,0x50000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE IROM2(0x10000000,0x80000) IROM3(0x0F100000,0x2000) IRAM2(0x30000000,0x50000)
  output: LVGL_WidgetsDemo
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: __320x240__ CPU_CORTEX_M33 LV_CONF_INCLUDE_SIMPLE NUFUN=1
  c misc: -mno-unaligned-access -Wconditional-uninitialized
  c include: ..\;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\m3331\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\..\..\ThirdParty\FreeRTOS\include;..\common;..\common\drv_disp;..\common\drv_indev;..\lv_port;..\..\..\..\ThirdParty\lvgl\src;..\..\..\..\ThirdParty\lvgl\src\core;..\..\..\..\ThirdParty\lvgl\src\draw;..\..\..\..\ThirdParty\lvgl\src\draw\sw;..\..\..\..\ThirdParty\lvgl\src\font;..\..\..\..\ThirdParty\lvgl\src\misc;..\..\..\..\ThirdParty\lvgl\src\widgets;..\..\..\..\ThirdParty\lvgl\demos\;..\..\..\..\ThirdParty\lvgl\demos\benchmark;..\..\..\..\ThirdParty\lvgl\demos\music;..\..\..\..\ThirdParty\lvgl\demos\stress;..\..\..\..\ThirdParty\lvgl\demos\widgets;..\..\..\..\ThirdParty\lvgl\demos\music\assets;..\..\..\..\ThirdParty\lvgl\demos\keypad_encoder;..\..\..\
  asm define: M3334KI
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\m3331\Config\m3331_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group src
    ../: main.c task_lv.c FreeRTOSConfig.h
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c pdma.c retarget.c sys.c uart.c spi.c eadc.c
    ../../../../Library/Device/Nuvoton/m3331/Source/: system_m3331.c startup_m3331.c
  group lvgl
    ../../../../ThirdParty/lvgl/src/: lv_init.c
    ../../../../ThirdParty/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../../../ThirdParty/lvgl/src/display/: lv_display.c
    ../../../../ThirdParty/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../../../ThirdParty/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../../../ThirdParty/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../../../../ThirdParty/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../../../../ThirdParty/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../../../ThirdParty/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../../../ThirdParty/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../../../../ThirdParty/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../../ThirdParty/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../../../ThirdParty/lvgl/src/layouts/: lv_layout.c
    ../../../../ThirdParty/lvgl/src/layouts/flex/: lv_flex.c
    ../../../../ThirdParty/lvgl/src/layouts/grid/: lv_grid.c
    ../../../../ThirdParty/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../../../ThirdParty/lvgl/src/libs/bmp/: lv_bmp.c
    ../../../../ThirdParty/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../../../../ThirdParty/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../../../../ThirdParty/lvgl/src/libs/gif/: lv_gif.c
    ../../../../ThirdParty/lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ../../../../ThirdParty/lvgl/src/libs/libpng/: lv_libpng.c
    ../../../../ThirdParty/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../../../../ThirdParty/lvgl/src/libs/lz4/: lz4.c
    ../../../../ThirdParty/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../../../../ThirdParty/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../../../ThirdParty/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../../../ThirdParty/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../../../ThirdParty/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../../../ThirdParty/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../../../../ThirdParty/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../../../ThirdParty/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../../../ThirdParty/lvgl/src/others/gridnav/: lv_gridnav.c
    ../../../../ThirdParty/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../../../ThirdParty/lvgl/src/others/imgfont/: lv_imgfont.c
    ../../../../ThirdParty/lvgl/src/others/monkey/: lv_monkey.c
    ../../../../ThirdParty/lvgl/src/others/observer/: lv_observer.c
    ../../../../ThirdParty/lvgl/src/others/snapshot/: lv_snapshot.c
    ../../../../ThirdParty/lvgl/src/others/sysmon/: lv_sysmon.c
    ../../../../ThirdParty/lvgl/src/others/translation/: lv_translation.c
    ../../../../ThirdParty/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../../../../ThirdParty/lvgl/src/stdlib/: lv_mem.c
    ../../../../ThirdParty/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../../../ThirdParty/lvgl/src/themes/: lv_theme.c
    ../../../../ThirdParty/lvgl/src/themes/default/: lv_theme_default.c
    ../../../../ThirdParty/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../../../ThirdParty/lvgl/src/themes/simple/: lv_theme_simple.c
    ../../../../ThirdParty/lvgl/src/tick/: lv_tick.c
    ../../../../ThirdParty/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../../../ThirdParty/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../../../ThirdParty/lvgl/src/widgets/arc/: lv_arc.c
    ../../../../ThirdParty/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../../../ThirdParty/lvgl/src/widgets/bar/: lv_bar.c
    ../../../../ThirdParty/lvgl/src/widgets/button/: lv_button.c
    ../../../../ThirdParty/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../../../ThirdParty/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../ThirdParty/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../../../ThirdParty/lvgl/src/widgets/chart/: lv_chart.c
    ../../../../ThirdParty/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../../../ThirdParty/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../../../ThirdParty/lvgl/src/widgets/image/: lv_image.c
    ../../../../ThirdParty/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../../../ThirdParty/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../../../ThirdParty/lvgl/src/widgets/label/: lv_label.c
    ../../../../ThirdParty/lvgl/src/widgets/led/: lv_led.c
    ../../../../ThirdParty/lvgl/src/widgets/line/: lv_line.c
    ../../../../ThirdParty/lvgl/src/widgets/list/: lv_list.c
    ../../../../ThirdParty/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../../../ThirdParty/lvgl/src/widgets/menu/: lv_menu.c
    ../../../../ThirdParty/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../../../ThirdParty/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../../../ThirdParty/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../../../ThirdParty/lvgl/src/widgets/roller/: lv_roller.c
    ../../../../ThirdParty/lvgl/src/widgets/scale/: lv_scale.c
    ../../../../ThirdParty/lvgl/src/widgets/slider/: lv_slider.c
    ../../../../ThirdParty/lvgl/src/widgets/span/: lv_span.c
    ../../../../ThirdParty/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../../../ThirdParty/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../../../ThirdParty/lvgl/src/widgets/switch/: lv_switch.c
    ../../../../ThirdParty/lvgl/src/widgets/table/: lv_table.c
    ../../../../ThirdParty/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../../../ThirdParty/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../../../ThirdParty/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../../../ThirdParty/lvgl/src/widgets/win/: lv_win.c
  group lv_port
    ../common/: lv_demo.c lv_port_disp.c lv_port_indev.c nu_misc.c
    ../lv_port/: lv_glue.c lv_glue.h drv_pdma.c drv_spi.c
    ../: lv_conf.h
    ../common/drv_disp/: disp_ili9341.c ili9341_spi.c
    ../common/drv_indev/: touch_adc.c touch_adc_calibration.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../ThirdParty/FreeRTOS/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
  group lv_demo
    ../../../../ThirdParty/lvgl/demos/: lv_demos.c
    ../../../../ThirdParty/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../../../../ThirdParty/lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
    ../../../../ThirdParty/lvgl/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
    ../../../../ThirdParty/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
