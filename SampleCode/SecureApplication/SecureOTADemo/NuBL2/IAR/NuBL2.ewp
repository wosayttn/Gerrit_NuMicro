# IAR project NuBL2.ewp, settings and files
configuration DirectBoot (ARM)
  General.OGChipSelectEditMenu: M5531x2LJAE series Nuvoton M5531x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; DEBUG_PORT=UART0_NS; NUMAKER_BOARD; x__DISABLE_MSG__
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\M5531\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\..\ThirdParty\FatFs\source; ..\OTA; ..\ESP; ..\..\ESP8266Lib; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NuBL2.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: SIGNED_HDR_SIZE=0x0
  ILINK.IlinkIcfFile: $PROJ_FNAME$.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration SecureBoot (ARM)
  as the first configuration, except:
  ILINK.IlinkConfigDefines: SIGNED_HDR_SIZE=0x400
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group ESP
    ../../ESP8266Lib/: buffer.c esp8266.c
    ../ESP/: esp8266_ll.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c crc.c crypto.c fmc.c gpio.c ks.c pmc.c retarget.c rng.c sys.c uart.c
    ../../../../../Library/StdDriver/src/scu/: mpc_sie_drv.c
  group OTA
    ../OTA/: CommandHandler.c ota.c ota_api.c ota_transfer.c
  group User
    ../: main.c NuBL2_Lib.c NuBL_crypto.c partition_M5531.h VerifyNuBL3x.c
