# Keil uVision project NuBL33.uvprojx, settings and files
target NuBL33_v1 (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: NuBL33_v1
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: python ..\..\FwSign.py ".\Objects\@L.bin" ..\UNSAFE_DEV_ONLY_KEY\ECC-P256.pem 0
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: NVT_CMSE_NON_SECURE, DEBUG_PORT=UART0_NS, NVT_VECTOR_ON_FLASH, NVT_DBG_UART_OFF
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\NuBL33.scf
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c gpio.c
  group User
    ../: main.c
    ../../NuBL32/lib/: nsclib_NuBL32.o
target NuBL33_v2 (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: NuBL33_v2
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: python ..\..\FwSign.py ".\Objects\@L.bin" ..\UNSAFE_DEV_ONLY_KEY\ECC-P256.pem 1
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: NVT_CMSE_NON_SECURE, DEBUG_PORT=UART0_NS, NVT_VECTOR_ON_FLASH, NVT_DBG_UART_OFF, __NEW_VER__
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\NuBL33.scf
