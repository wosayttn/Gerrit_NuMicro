# Keil uVision project NuBL33.uvprojx, settings and files
target NuBL33 (6220000::V6.22::ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: NuBL33
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L"
  AfterMake: FwSign.bat NuBL33\NuBL33.bin NuBL33\FwInfo.bin 0x10078000
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEBUG_PORT=UART0_NS
  c include: ..\..\NuBL33;;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M2354\Include;..\..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\NuBL33.sct
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
 --keep=FwInfo.o(*)
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../../../../Library/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.S
  group User
    ../: main.c
    ../FwInfo/: FwInfo.c
    ./: FwSign.ini
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c
    ../../NuBL32/lib/: nsclib_NuBL32.o
