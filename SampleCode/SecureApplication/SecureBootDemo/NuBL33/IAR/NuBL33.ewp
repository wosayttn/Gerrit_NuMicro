# IAR project NuBL33.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M5531x2LJAE series Nuvoton M5531x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; NVT_CMSE_NON_SECURE; DEBUG_PORT=UART0_NS; NVT_DBG_UART_OFF; NVT_VECTOR_ON_FLASH
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\M5531\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NuBL33.bin
  ILINK.IlinkOutputFile: NuBL33.out
  ILINK.IlinkConfigDefines: SIGNED_HDR_SIZE=0x400
  ILINK.IlinkIcfFile: NuBL33.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Library
    ../../../../../Library/StdDriver/src/: gpio.c retarget.c
  group User
    ../: main.c
    ../../NuBL32/IAR/Release/Exe/: nsclib_NuBL32.o
