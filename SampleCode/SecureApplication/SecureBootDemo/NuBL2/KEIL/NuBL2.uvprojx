# Keil uVision project NuBL2.uvprojx, settings and files
target NuBL2_DirectBoot (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: NuBL2_DirectBoot
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: MBEDTLS_CONFIG_FILE, DEBUG_PORT=UART0_NS
  c include: ..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\Device\Nuvoton\M3351\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\Library\CryptoAccelerator;..\..\..\..\..\ThirdParty\mbedtls-3.1.0\include;..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\NuBL2.scf
  link misc: --import-cmse-lib-out ..\lib\nsclib_NuBL2.o --pd="-DSIGNED_HDR_SIZE=0x0"
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c fmc.c crypto.c
    ../../../../../Library/CryptoAccelerator/lib/: mbedcrypto.lib
  group User
    ../../: partition_M3351.h
    ../: main.c active_sc.c VerifyNuBL3x.c crypto_mbedtls.c
target NuBL2_SecureBoot (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: NuBL2_SecureBoot
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: ..\..\FwSign.bat ".\Objects\@L.bin" ..\FwKey\ECC-P256.pem 0
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: MBEDTLS_CONFIG_FILE, DEBUG_PORT=UART0_NS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\NuBL2.scf
  link misc: --import-cmse-lib-out ..\lib\nsclib_NuBL2.o --pd="-DSIGNED_HDR_SIZE=0x400"
