# IAR project dsp_fft.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M471 series Nuvoton M471 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4=1UL; __FPU_PRESENT=1UL
  ICCARM.CCDiagSuppress: Pa082, Pa093
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M471\Include; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\CMSIS\DSP\Include; ..\..\..\..\Library\CMSIS\DSP\PrivateInclude; ..\..\..\..\Library\CMSIS\DSP\Source\SupportFunctions; ..\..\..\..\Library\CMSIS\DSP\Source\TransformFunctions; ..\..\..\..\Library\CMSIS\DSP\Source\StatisticsFunctions; ..\..\..\..\Library\CMSIS\DSP\Source\ComplexMathFunctions; ..\..\..\..\Library\CMSIS\DSP\Source\CommonTables
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dsp_fft.bin
  ILINK.IlinkOutputFile: DSP_FFT.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471/Source/IAR/: startup_M471.s
    ../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: arm_fft_bin_data.c DSP_Functions.c main.c
