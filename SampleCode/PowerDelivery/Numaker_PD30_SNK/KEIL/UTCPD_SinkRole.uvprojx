# Keil uVision project UTCPD_SinkRole.uvprojx, settings and files
target UTCPD_SinkRole (6230000::V6.23::ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2A000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: UTCPD_SinkRole
  AfterMake: fromelf --bin ".\obj\Transmit\@L.axf" --output ".\obj\Transmit\@L.bin"
  AfterMake: fromelf --text -c ".\obj\Transmit\@L.axf" --output ".\obj\Transmit\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6Lto=1 wLevel=3
  c define: OPT_SNK_ONLY=1, OPT_SRC_ONLY=0, DEBUG_PORT=UART0
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\PowerDeliveryLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  link misc: --map --first='startup_M2L31.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
    ../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c timer.c gpio.c eadc.c utcpd.c acmp.c
    ../../../../Library/PowerDeliveryLib/: PD_SNK_Keil.lib
  group User
    ../: main.c usb_pd_policy.c usb_powerctrl.c usb_MultipleFunction.c ec_adc.c commandshell.c
