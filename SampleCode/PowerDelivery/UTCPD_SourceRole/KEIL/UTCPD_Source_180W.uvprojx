# Keil uVision project UTCPD_Source_180W.uvprojx, settings and files
target UTCPD_SourceRole (6230000::V6.23::ARMCLANG)
  device: M2003FC1AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: UTCPD_SRC_180W
  AfterMake: fromelf --bin ".\obj\Transmit\@L.axf" --output ".\obj\Transmit\@L.bin"
  AfterMake: fromelf --text -c ".\obj\Transmit\@L.axf" --output ".\obj\Transmit\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 v6Lto=1 wLevel=1
  c define: CONFIG_OB_SOLUTION=1, OPT_FPGA=0, DEBUG_PORT=UART0, OPT_CAPTIVE_CABLE=1, OPT_M2003=1, NPD48_ALERT=GPB_IRQn, OPT_SRC_ONLY=1, OPT_SNK_ONLY=0  NPD48_FPGA=0, CONFIG_USB_PD_TCPC_RUNTIME_CONFIG  CHROMIUM_EC=1 CONFIG_USB_PD_FRS_TCPC=0  CONFIG_USB_PD_REV30=1 CONFIG_TC8260_FRS=0,
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M2003\Include;..\..\..\..\Library\Device\Nuvoton\NPD48\Include;..\..\..\..\Library\PowerDeliveryLib\Include;..\..\..\..\Library\PowerDeliveryLib\Include\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\scatter.scf
  link misc: --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003/Source/: system_M2003.c
    ./: startup_M2003_PD.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c sys.c timer.c gpio.c i2c.c
  group NPD48 _Driver
    ../../../../Library/Device/Nuvoton/NPD48/src/: i2c_interrupt.c utcpd.c
  group User
    ../: main.c usb_pd_policy.c commandshell.c NPD48_ADC.c NPD48_Protection.c NPD48_VINGATE2_CTRL.c NPD48_VBUS_DrawnCurrent_Compensation.c NPD48_InterConnection.c usb_pd_falling_transition.c NPD48_ChipInit.c
  group Lib
    ../../../../Library/PowerDeliveryLib/: PD_SRC.lib
