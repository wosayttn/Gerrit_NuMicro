# Keil uVision project UTCPD_SinkRole.uvprojx, settings and files
target UTCPD_SinkRole (6240000::V6.24::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: UTCPD_SinkRole
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: OPT_SNK_ONLY=1, OPT_SRC_ONLY=0,E_VBUS_DIVIDER = 10,USING_UART0 = 1
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M5531\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\PowerDeliveryLib\Include;..\..\..\..\Library\PowerDeliveryLib\Include\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M5531\Source\ARM\M5531.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c sys.c gpio.c retarget.c uart.c eadc.c acmp.c timer.c utcpd.c
  group User
    ../: main.c usb_powerctrl.c usb_pd_policy.c usb_MultipleFunction.c ec_adc.c commandshell.c
  group Library
    ../../../../Library/PowerDeliveryLib/: PD_SNK.lib
