# Keil uVision project UTCPD_DualRole.uvprojx, settings and files
target UTCPD_DualRole (6230000::V6.23::ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x2A000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: UTCPD_DualRole
  AfterMake: fromelf --bin ".\obj\Transmit\@L.axf" --output ".\obj\Transmit\@L.bin"
  AfterMake: fromelf --text -c ".\obj\Transmit\@L.axf" --output ".\obj\Transmit\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: OPT_DRP=1 DEBUG_PORT=UART0
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\PowerDeliveryLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  link misc: --map --first='startup_M2L31.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
    ../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c timer.c gpio.c eadc.c acmp.c utcpd.c i2c.c
    ../../../../Library/PowerDeliveryLib/: PD_DRP_Keil.lib
  group User
    ../: main.c usb_pd_policy.c usb_powerctrl.c usb_MultipleFunction.c ec_adc.c commandshell.c usb_pd_deadbattery.c
  group Peripheral
    ../: battery.c charger.c rt9490.c ina219.c ocp_handler.c
