# IAR project UTCPD_DualRole.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2L31 series Nuvoton M2L31 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: OPT_DRP=1; DEBUG_PORT=UART0
  ICCARM.CCDiagSuppress: Pa093, Pa082, Pe177, Pe188
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2L31\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\PowerDeliveryLib\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UTCPD_DualRole.bin
  ILINK.IlinkOutputFile: UTCPD_DualRole.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/IAR/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group Library
    ../../../../Library/StdDriver/src/: acmp.c clk.c eadc.c gpio.c i2c.c retarget.c sys.c timer.c uart.c utcpd.c
    ../../../../Library/PowerDeliveryLib/: PD_DRP.a
  group Peripheral
    ../: battery.c charger.c ina219.c ocp_handler.c rt9490.c usb_pd_deadbattery.c
  group User
    ../: commandshell.c ec_adc.c main.c usb_MultipleFunction.c usb_pd_policy.c usb_powerctrl.c
