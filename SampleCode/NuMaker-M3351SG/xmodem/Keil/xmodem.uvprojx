# Keil uVision project xmodem.uvprojx, settings and files
target xmodem (6240000::V6.24::ARMCLANG)
  device: M3351SG7AE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.6
  cpu: IRAM(0x20000000,0xC000) IRAM2(0x30000000,0xC000) IROM(0x00000000,0x40000) IROM2(0x0F100000,0x4000) IROM3(0x10000000,0x40000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: xmodem
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\CMSIS\compiler\include;..\..\..\..\Library\Device\Nuvoton\M3351\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Commu
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0xf100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x30000000 size 0xc000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M3351\Source\ARM\M3351xG.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c fmc.c
    ../../../../Library/Commu/: xmodem.c
  group User
    ../: main.c
